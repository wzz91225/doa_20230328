options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: test_phase_shift
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: phase_sig_src_x
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '1e-2'
    stop: '1'
    value: '0'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793238462643'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.2'
    stop: '100'
    value: '0'
  states: {}
- name: phase_shift_x
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: '0'
  states: {}
- name: phase_shift_y
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: phase_sig_src_x*pi
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"x&y phase shift"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: sig_src_sincos
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    bw0: samp_rate
    center_freq0: 2.4e9
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 2.4e9
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [phase_shift_x, '0', qtgui_time_sink_x_1, '0']
- [phase_shift_y, '0', uhd_usrp_sink_0, '0']
- [sig_src_sincos, '0', phase_shift_x, '0']
- [sig_src_sincos, '0', phase_shift_y, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
