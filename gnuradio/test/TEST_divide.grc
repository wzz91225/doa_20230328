options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: TEST_divide
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '50'
  states: {}
- name: variable_qtgui_entry_1
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '50'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: variable_qtgui_entry_0
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: variable_qtgui_entry_1
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: d20230403_hier_atan_epb_0_0
  id: d20230403_hier_atan_epb
  parameters: {}
  states: {}
- name: qtgui_number_sink_2_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: DOA rms^2 (deg)
    max: '90'
    min: '-90'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0_0, '0']
- [analog_const_source_x_1, '0', blocks_divide_xx_0_0, '1']
- [blocks_divide_xx_0_0, '0', d20230403_hier_atan_epb_0_0, '0']
- [d20230403_hier_atan_epb_0_0, '1', qtgui_number_sink_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
