options:
  parameters:
    author: zzaw
    description: '[-pi/2, pi/2]'
    generate_options: qt_gui
    id: TEST_atan_epb
    output_language: python
    title: atan (epb)
  states: {}

blocks:
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793238462643'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: value
  id: variable_qtgui_range
  parameters:
    start: '-1e2'
    step: '1e-1'
    stop: 1e2
    value: '1'
  states: {}
- name: value_x
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1'
  states: {}
- name: value_y
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: value
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: value_x
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: value_y
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180/pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180/pi
    type: float
  states: {state: disabled}
- name: d20230403_hier_atan_epb_0
  id: d20230403_hier_atan_epb
  parameters: {}
  states: {}
- name: d20230404_hier_atan2_epb_0
  id: d20230404_hier_atan2_epb
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='atan (epb)',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.arctan(input_items[0])
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='atan (epb)',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.arctan2(input_items[0], input_items[1])
              return len(output_items[0])
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: pi
    min: '-pi'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '-180'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '-180'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: pi
    min: '-pi'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', d20230403_hier_atan_epb_0, '0']
- [analog_const_source_x_0, '0', epy_block_0, '0']
- [analog_const_source_x_0_0, '0', d20230404_hier_atan2_epb_0, '0']
- [analog_const_source_x_0_0, '0', epy_block_0_0, '0']
- [analog_const_source_x_0_1, '0', d20230404_hier_atan2_epb_0, '1']
- [analog_const_source_x_0_1, '0', epy_block_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [d20230403_hier_atan_epb_0, '0', qtgui_number_sink_0, '0']
- [d20230403_hier_atan_epb_0, '1', qtgui_number_sink_0_0, '0']
- [d20230404_hier_atan2_epb_0, '0', qtgui_number_sink_0_1, '0']
- [d20230404_hier_atan2_epb_0, '1', qtgui_number_sink_0_0_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_0_0, '0', qtgui_number_sink_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
