options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: TEST_doa_power_spectrum
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: RF_rx0_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-1'
    stop: '100'
    value: '0'
  states: {}
- name: RF_rx1_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-1'
    stop: '100'
    value: '0'
  states: {}
- name: RF_rx_center_freq
  id: variable
  parameters:
    value: RF_tx_center_freq
  states: {}
- name: RF_tx_center_freq
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 6e9
    value: 315e6
  states: {}
- name: RF_tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-1'
    stop: '100'
    value: '0'
  states: {}
- name: TH_Factor_Fall
  id: variable_qtgui_range
  parameters:
    start: '1e-1'
    step: '1e-2'
    stop: 1e2
    value: '10'
  states: {state: disabled}
- name: TH_Factor_Fall
  id: variable
  parameters:
    value: TH_Factor_Rise
  states: {}
- name: TH_Factor_Rise
  id: variable_qtgui_range
  parameters:
    start: '1e-1'
    step: '1e-2'
    stop: 1e2
    value: '10'
  states: {}
- name: amp_sig_src
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-1'
    stop: '4'
    value: '1'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: freq_sig_src
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: 1e4
    value: '1000'
  states: {}
- name: period_peak_detector
  id: variable_qtgui_range
  parameters:
    start: '1e-1'
    step: '1e-1'
    stop: 1e1
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_sig_src
    freq: freq_sig_src
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: d20230402_hier_CenterFreqDetector_0
  id: d20230402_hier_CenterFreqDetector
  parameters:
    TH_Factor_Fall: TH_Factor_Fall
    TH_Factor_Rise: TH_Factor_Rise
    fft_size: fft_size
    period_peak_detector: '1'
    samp_rate: samp_rate
  states: {}
- name: d20230402_hier_CenterFreqDetector_0_0
  id: d20230402_hier_CenterFreqDetector
  parameters:
    TH_Factor_Fall: TH_Factor_Fall
    TH_Factor_Rise: TH_Factor_Rise
    fft_size: fft_size
    period_peak_detector: '1'
    samp_rate: samp_rate
  states: {}
- name: d20230402_hier_PowerSpectrum_0
  id: d20230402_hier_PowerSpectrum
  parameters:
    fft_size: '65536'
    samp_rate: 32e3
  states: {state: disabled}
- name: d20230402_hier_PowerSpectrum_1
  id: d20230402_hier_PowerSpectrum
  parameters:
    fft_size: '65536'
    samp_rate: 32e3
  states: {state: disabled}
- name: d20230403_hier_atan_epb_0
  id: d20230403_hier_atan_epb
  parameters: {}
  states: {}
- name: d20230403_hier_atan_epb_0_0
  id: d20230403_hier_atan_epb
  parameters: {}
  states: {}
- name: d20230403_hier_atan_epb_0_0_0
  id: d20230403_hier_atan_epb
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_number_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"peak_detected"'
    min: '0'
    type: byte
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"peak_detected"'
    min: '0'
    type: byte
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: '"freq_detected"'
    label2: '"power_spectrum_detected(dB)"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: '"freq_detected"'
    label2: '"power_spectrum_detected(dB)"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: '"power0"'
    label2: '"power1"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: '"rms0^2"'
    label2: '"rms1^2"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: '"rms0^1"'
    label2: '"rms1^1"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: DOA power (deg)
    max: '90'
    min: '-90'
    type: float
  states: {}
- name: qtgui_number_sink_2_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: DOA rms^2 (deg)
    max: '90'
    min: '-90'
    type: float
  states: {}
- name: qtgui_number_sink_2_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: DOA rms^1 (deg)
    max: '90'
    min: '-90'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: fft_size
    x_start: '0'
    x_step: 1e3/samp_rate*1024/fft_size
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    bw0: samp_rate
    center_freq0: RF_tx_center_freq
    gain0: RF_tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: RF_rx_center_freq
    center_freq1: RF_rx_center_freq
    gain0: RF_rx0_gain
    gain1: RF_rx1_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: vsink_rx0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: vsink_rx1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: vsrc_rx0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: vsrc_rx0_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {state: disabled}
- name: vsrc_rx0_1
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: vsrc_rx0_2
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: vsrc_rx1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: vsrc_rx1_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {state: disabled}
- name: vsrc_rx1_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: vsrc_rx1_2
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_sink_x_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_divide_xx_0, '0', d20230403_hier_atan_epb_0, '0']
- [blocks_divide_xx_0_0, '0', d20230403_hier_atan_epb_0_0, '0']
- [blocks_divide_xx_0_0_0, '0', d20230403_hier_atan_epb_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_number_sink_1_0_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_divide_xx_0_0, '1']
- [blocks_multiply_xx_1, '0', qtgui_number_sink_1_0_0_0, '1']
- [blocks_rms_xx_0, '0', blocks_divide_xx_0_0_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_rms_xx_0, '0', qtgui_number_sink_1_0_0_0_0, '0']
- [blocks_rms_xx_1, '0', blocks_divide_xx_0_0_0, '1']
- [blocks_rms_xx_1, '0', blocks_multiply_xx_1, '0']
- [blocks_rms_xx_1, '0', blocks_multiply_xx_1, '1']
- [blocks_rms_xx_1, '0', qtgui_number_sink_1_0_0_0_0, '1']
- [d20230402_hier_CenterFreqDetector_0, '0', blocks_null_sink_0, '0']
- [d20230402_hier_CenterFreqDetector_0, '0', qtgui_number_sink, '0']
- [d20230402_hier_CenterFreqDetector_0, '1', qtgui_number_sink_1, '0']
- [d20230402_hier_CenterFreqDetector_0, '2', blocks_divide_xx_0, '0']
- [d20230402_hier_CenterFreqDetector_0, '2', qtgui_number_sink_1_0_0, '0']
- [d20230402_hier_CenterFreqDetector_0, '3', qtgui_number_sink_1, '1']
- [d20230402_hier_CenterFreqDetector_0_0, '0', blocks_null_sink_1, '0']
- [d20230402_hier_CenterFreqDetector_0_0, '0', qtgui_number_sink_0, '0']
- [d20230402_hier_CenterFreqDetector_0_0, '1', qtgui_number_sink_1_0, '0']
- [d20230402_hier_CenterFreqDetector_0_0, '2', blocks_divide_xx_0, '1']
- [d20230402_hier_CenterFreqDetector_0_0, '2', qtgui_number_sink_1_0_0, '1']
- [d20230402_hier_CenterFreqDetector_0_0, '3', qtgui_number_sink_1_0, '1']
- [d20230402_hier_PowerSpectrum_0, '1', qtgui_vector_sink_f_0, '0']
- [d20230402_hier_PowerSpectrum_1, '1', qtgui_vector_sink_f_0, '1']
- [d20230403_hier_atan_epb_0, '1', qtgui_number_sink_2, '0']
- [d20230403_hier_atan_epb_0_0, '1', qtgui_number_sink_2_0, '0']
- [d20230403_hier_atan_epb_0_0_0, '1', qtgui_number_sink_2_0_0, '0']
- [uhd_usrp_source_0, '0', vsink_rx0, '0']
- [uhd_usrp_source_0, '1', vsink_rx1, '0']
- [vsrc_rx0, '0', qtgui_freq_sink_x_0, '0']
- [vsrc_rx0_0, '0', d20230402_hier_PowerSpectrum_0, '0']
- [vsrc_rx0_1, '0', d20230402_hier_CenterFreqDetector_0, '0']
- [vsrc_rx0_2, '0', blocks_rms_xx_0, '0']
- [vsrc_rx1, '0', qtgui_freq_sink_x_0, '1']
- [vsrc_rx1_0, '0', d20230402_hier_PowerSpectrum_1, '0']
- [vsrc_rx1_1, '0', d20230402_hier_CenterFreqDetector_0_0, '0']
- [vsrc_rx1_2, '0', blocks_rms_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
