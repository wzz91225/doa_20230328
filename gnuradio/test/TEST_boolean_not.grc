options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: TEST_boolean_not
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: datain
  id: variable_qtgui_chooser
  parameters:
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: datain
    type: byte
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: datain
    type: byte
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: using "Xor" SUCCESS
    label2: using "Not" FAIL
    max: '2'
    min: '-2'
    nconnections: '2'
    type: byte
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '0']
- [analog_const_source_x_0_0, '0', blocks_xor_xx_0, '1']
- [analog_const_source_x_0_1, '0', blocks_not_xx_0, '0']
- [blocks_not_xx_0, '0', qtgui_number_sink_0, '1']
- [blocks_xor_xx_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
