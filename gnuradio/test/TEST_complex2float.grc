options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: TEST_complex2float
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '2'
    value: '1'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793238462643'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    label0: GR_SIN_WAVE
    label1: GR_COS_WAVE
    label2: GR_SQR_WAVE
    label3: GR_TRI_WAVE
    label4: GR_SAW_WAVE
    num_opts: '5'
    option0: '101'
    option1: '102'
    option2: '103'
    option3: '104'
    option4: '105'
    type: raw
    value: '101'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: d20230320_hier_complex2float_0
  id: d20230320_hier_complex2float
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: real
    label2: imag
    label3: mag
    label4: mag^2
    label5: real
    label6: rms
    label7: OOT_complex2float
    label8: real+imag
    label9: real^2+imag^2
    nconnections: '9'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: sig_imag
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: sig_imag_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: sig_real
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: sig_real_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: sig_src
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: waveform
  states: {}
- name: virtal_sink_sig_imag
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtal_sink_sig_real
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '7']
- [blocks_add_xx_0_0, '0', qtgui_time_sink_x_0, '8']
- [blocks_complex_to_float_0, '0', virtal_sink_sig_real, '0']
- [blocks_complex_to_float_0, '1', virtal_sink_sig_imag, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_rms_xx_0, '0', qtgui_time_sink_x_0, '5']
- [d20230320_hier_complex2float_0, '0', qtgui_time_sink_x_0, '6']
- [sig_imag, '0', qtgui_time_sink_x_0, '1']
- [sig_imag_0, '0', blocks_add_xx_0, '1']
- [sig_imag_0, '0', blocks_multiply_xx_0_0, '0']
- [sig_imag_0, '0', blocks_multiply_xx_0_0, '1']
- [sig_real, '0', qtgui_time_sink_x_0, '0']
- [sig_real_0, '0', blocks_add_xx_0, '0']
- [sig_real_0, '0', blocks_multiply_xx_0, '0']
- [sig_real_0, '0', blocks_multiply_xx_0, '1']
- [sig_src, '0', blocks_complex_to_float_0, '0']
- [sig_src, '0', blocks_complex_to_mag_0, '0']
- [sig_src, '0', blocks_complex_to_mag_squared_0, '0']
- [sig_src, '0', blocks_complex_to_real_0, '0']
- [sig_src, '0', blocks_rms_xx_0, '0']
- [sig_src, '0', d20230320_hier_complex2float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
