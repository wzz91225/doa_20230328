options:
  parameters:
    author: zzaw
    description: 'Deps: MarcinWachowiak/gr-aoa'
    generate_options: qt_gui
    id: TEST_phase_difference
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: delta_phase
  id: variable_qtgui_range
  parameters:
    start: '-pi'
    step: pi*1e-2
    stop: pi
    value: '0'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 1e3
    step: pi*1e-2
    stop: samp_rate / 2
    value: 8e3
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '0'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: signal_multiplying
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
  states: {}
- name: HIER_AddGaussianNoise_0
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: noise_amp
    random_seed: '10492'
  states: {}
- name: HIER_DataError_0
  id: HIER_DataError
  parameters: {}
  states: {}
- name: HIER_DataError_0_0
  id: HIER_DataError
  parameters: {}
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: delta_phase
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: delta_phase
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_calc_phase_diff_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: aoa_calc_phase_diff_1
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: frequency*1.1
    low_cutoff_freq: frequency*0.9
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: frequency*0.2
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: signal_multiplying
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: '-delta_phase'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: pi
    min: '-pi'
    nconnections: '2'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: err
    label2: '%'
    max: '100'
    min: '0'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: err (with bandpass)
    label2: '% (with bandpass)'
    max: '100'
    min: '0'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"SNR"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.010'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [HIER_AddGaussianNoise_0, '0', aoa_calc_phase_diff_0, '1']
- [HIER_AddGaussianNoise_0, '0', band_pass_filter_0, '0']
- [HIER_AddGaussianNoise_0, '0', qtgui_time_sink_x_0, '1']
- [HIER_AddGaussianNoise_0, '1', qtgui_number_sink_2, '0']
- [HIER_DataError_0, '0', qtgui_number_sink_1, '0']
- [HIER_DataError_0, '1', qtgui_number_sink_1, '1']
- [HIER_DataError_0_0, '0', qtgui_number_sink_1_0, '0']
- [HIER_DataError_0_0, '1', qtgui_number_sink_1_0, '1']
- [analog_const_source_x_0, '0', HIER_DataError_0, '1']
- [analog_const_source_x_0_0, '0', HIER_DataError_0_0, '1']
- [analog_sig_source_x_0, '0', aoa_calc_phase_diff_0, '0']
- [analog_sig_source_x_0, '0', aoa_calc_phase_diff_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_xx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [aoa_calc_phase_diff_0, '0', HIER_DataError_0, '0']
- [aoa_calc_phase_diff_0, '0', qtgui_number_sink_0, '0']
- [aoa_calc_phase_diff_1, '0', HIER_DataError_0_0, '0']
- [aoa_calc_phase_diff_1, '0', qtgui_number_sink_0, '1']
- [band_pass_filter_0, '0', aoa_calc_phase_diff_1, '1']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_multiply_const_xx_0, '0', blocks_phase_shift_0, '0']
- [blocks_phase_shift_0, '0', HIER_AddGaussianNoise_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
