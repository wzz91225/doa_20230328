options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: TEST_peak_detector
    output_language: python
    title: peak_detector
  states: {}

blocks:
- name: TH_Factor_Fall
  id: variable_qtgui_range
  parameters:
    start: '1e-1'
    step: '1e-2'
    stop: 1e1
    value: '0.4'
  states: {}
- name: TH_Factor_Rise
  id: variable_qtgui_range
  parameters:
    start: '1e-1'
    step: '1e-2'
    stop: 1e1
    value: '0.25'
  states: {}
- name: amp_sig_src
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0
    start: '0'
    step: '1e-1'
    stop: '4'
    value: '1'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: freq_sig_src
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0
    start: '0'
    step: '1'
    stop: 1e4
    value: '1000'
  states: {}
- name: period_peak_detector
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0
    start: '1e-1'
    step: '1e-1'
    stop: 1e1
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_sig_src
    freq: freq_sig_src
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-freq_sig_src'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1e2/freq_sig_src
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*1e2
    type: complex
  states: {state: disabled}
- name: d20130403_hier_Bool_NOT_0
  id: d20130403_hier_Bool_NOT
  parameters: {}
  states: {state: disabled}
- name: d20230402_hier_PeriodicCenterFreqDetector_0
  id: d20230402_hier_PeriodicCenterFreqDetector
  parameters:
    TH_Factor_Fall: TH_Factor_Fall
    TH_Factor_Rise: TH_Factor_Rise
    fft_size: fft_size
    period_peak_detector: '1'
    samp_rate: samp_rate
  states: {}
- name: qtgui_number_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 5,0
    label1: '"peak_detected"'
    min: '0'
    type: byte
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 6, 0
    label1: '"freq_detected"'
    label2: '"power_spectrum_detected(dB)"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 7, 0
    label1: '"freq_err(%)"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: '"freq_err(%)"'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3, 0
    type: complex
  states: {}
- name: vsink_sig_src
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: vsrc_sig_src
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', vsink_sig_src, '0']
- [blocks_abs_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_abs_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_number_sink_1_0, '0']
- [blocks_sample_and_hold_xx_0, '0', qtgui_number_sink_1_0_0, '0']
- [blocks_throttle_0, '0', vsink_sig_src, '0']
- [d20130403_hier_Bool_NOT_0, '0', blocks_sample_and_hold_xx_0, '1']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '0', d20130403_hier_Bool_NOT_0, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '0', qtgui_number_sink, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '1', blocks_add_const_vxx_0, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '1', blocks_sample_and_hold_xx_0, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '1', qtgui_number_sink_1, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '3', qtgui_number_sink_1, '1']
- [vsrc_sig_src, '0', d20230402_hier_PeriodicCenterFreqDetector_0, '0']
- [vsrc_sig_src, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
