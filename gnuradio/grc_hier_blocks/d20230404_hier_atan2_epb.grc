options:
  parameters:
    author: zzaw
    description: '[-pi, pi]'
    generate_options: hb
    id: d20230404_hier_atan2_epb
    output_language: python
    title: atan(x/y) (epb)
  states: {}

blocks:
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793238462643'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180/pi
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='atan (epb)',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.arctan2(input_items[0], input_items[1])
              return len(output_items[0])
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: rad
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: deg
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: x
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: y
    type: float
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_null_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0_0, '0']
- [epy_block_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0_0, '0', blocks_null_sink_0, '0']
- [epy_block_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', epy_block_0_0, '0']
- [pad_source_1, '0', epy_block_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
