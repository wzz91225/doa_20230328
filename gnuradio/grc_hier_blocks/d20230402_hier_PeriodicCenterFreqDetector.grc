options:
  parameters:
    author: zzaw
    generate_options: hb
    id: d20230402_hier_PeriodicCenterFreqDetector
    output_language: python
    title: Periodic Center Frequency Detector
  states: {}

blocks:
- name: TH_Factor_Fall
  id: parameter
  parameters:
    label: TH_Factor_Fall
    type: eng_float
    value: '0.4'
  states: {}
- name: TH_Factor_Rise
  id: parameter
  parameters:
    label: TH_Factor_Rise
    type: eng_float
    value: '0.25'
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: fft_size
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/fft_size
    type: float
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: d20230402_hier_PeriodicPeakDetector_0
  id: d20230402_hier_PeriodicPeakDetector
  parameters:
    TH_Factor_Fall: TH_Factor_Fall
    TH_Factor_Rise: TH_Factor_Rise
    period_peak_detector: period_peak_detector
    samp_rate: samp_rate
  states: {}
- name: d20230402_hier_PowerSpectrum_0
  id: d20230402_hier_PowerSpectrum
  parameters:
    fft_size: fft_size
    samp_rate: samp_rate
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: fft_size
    type: intx
    value: '32768'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: detected
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: freq
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: power
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: pow_dB
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: period_peak_detector
  id: parameter
  parameters:
    label: period_peak_detector
    type: eng_float
    value: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: 32e3
  states: {}

connections:
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_max_xx_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_max_xx_0, '0', blocks_null_sink_1, '0']
- [blocks_max_xx_0, '0', pad_sink_2, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_1, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_null_sink_2, '0']
- [blocks_nlog10_ff_0_0_0, '0', pad_sink_3, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', d20230402_hier_PeriodicPeakDetector_0, '0']
- [d20230402_hier_PeriodicPeakDetector_0, '0', pad_sink_0, '0']
- [d20230402_hier_PowerSpectrum_0, '0', blocks_argmax_xx_0, '0']
- [d20230402_hier_PowerSpectrum_0, '0', blocks_max_xx_0, '0']
- [d20230402_hier_PowerSpectrum_0, '0', blocks_vector_to_stream_0, '0']
- [pad_source_0, '0', d20230402_hier_PowerSpectrum_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
