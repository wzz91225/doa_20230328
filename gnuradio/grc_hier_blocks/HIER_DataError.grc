options:
  parameters:
    author: zzaw
    generate_options: hb
    id: HIER_DataError
    output_language: python
    title: Data Error
  states: {}

blocks:
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Data Error (%)',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if input_items[1] != 0:
                  output_items[0][:] = np.abs(input_items[0] - input_items[1]) / input_items[1] * 100
              else:
                  output_items[0][:] = np.abs(input_items[0]) / np.inf
              return len(output_items[0])
  states: {state: disabled}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: abs
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: (%)
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: measured
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: expected
    type: float
  states: {}

connections:
- [blocks_abs_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_abs_xx_1, '0', blocks_null_sink_0, '0']
- [blocks_abs_xx_1, '0', pad_sink_0, '0']
- [blocks_divide_xx_0, '0', blocks_abs_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_null_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_1, '0']
- [blocks_sub_xx_0, '0', blocks_abs_xx_1, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [epy_block_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_sub_xx_0, '0']
- [pad_source_0, '0', epy_block_0, '0']
- [pad_source_1, '0', blocks_divide_xx_0, '1']
- [pad_source_1, '0', blocks_sub_xx_0, '1']
- [pad_source_1, '0', epy_block_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
