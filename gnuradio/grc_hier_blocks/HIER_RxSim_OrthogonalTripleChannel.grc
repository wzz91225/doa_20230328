options:
  parameters:
    author: zzaw
    category: '[DoA -  wzz91225]'
    description: Orthogonal triple channels
    generate_options: hb
    id: HIER_RxSim_OrthogonalTripleChannel
    output_language: python
    title: Receiver Simulation - Orthogonal Triple Channels
  states: {}

blocks:
- name: HIER_cos_angle_epb_0
  id: HIER_cos_angle_epb
  parameters: {}
  states: {}
- name: HIER_cos_angle_epb_1
  id: HIER_cos_angle_epb
  parameters: {}
  states: {}
- name: HIER_sin_angle_epb_0
  id: HIER_sin_angle_epb
  parameters: {}
  states: {}
- name: HIER_sin_angle_epb_1
  id: HIER_sin_angle_epb
  parameters: {}
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: azimuth_angle
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: pitch_angle
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: azimuth_angle
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_3
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: ch1
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: ch2
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: ch3
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: signal
    type: complex
  states: {}
- name: pitch_angle
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [HIER_cos_angle_epb_0, '0', blocks_float_to_complex_1, '0']
- [HIER_cos_angle_epb_1, '0', blocks_float_to_complex_3, '0']
- [HIER_sin_angle_epb_0, '0', blocks_float_to_complex_0, '0']
- [HIER_sin_angle_epb_1, '0', blocks_float_to_complex_2, '0']
- [analog_const_source_x_0, '0', HIER_cos_angle_epb_0, '0']
- [analog_const_source_x_0, '0', HIER_sin_angle_epb_0, '0']
- [analog_const_source_x_1, '0', HIER_cos_angle_epb_1, '0']
- [analog_const_source_x_1, '0', HIER_sin_angle_epb_1, '0']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_1, '1']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_2, '1']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_3, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_3, '0']
- [blocks_float_to_complex_1, '0', blocks_multiply_xx_2, '0']
- [blocks_float_to_complex_2, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_3, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_2, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_3, '1']
- [blocks_multiply_xx_1, '0', pad_sink_2, '0']
- [blocks_multiply_xx_2, '0', pad_sink_0, '0']
- [blocks_multiply_xx_3, '0', pad_sink_1, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
