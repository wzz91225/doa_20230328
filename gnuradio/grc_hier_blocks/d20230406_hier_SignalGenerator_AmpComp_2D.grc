options:
  parameters:
    category: '[DoA -  wzz91225]'
    generate_options: hb
    id: d20230406_hier_SignalGenerator_AmpComp_2D
    output_language: python
    title: Signal Generator - AmpComp - 2D
  states: {}

blocks:
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: parameter_0
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: d20230403_hier_cos_angle_epb_0
  id: d20230403_hier_cos_angle_epb
  parameters: {}
  states: {}
- name: d20230403_hier_sin_angle_epb_0
  id: d20230403_hier_sin_angle_epb
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: ch1
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: ch2
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: signal
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: angle
    type: float
  states: {state: disabled}
- name: parameter_0
  id: parameter
  parameters:
    label: angle
    value: '0'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_1, '0', blocks_float_to_complex_1, '1']
- [analog_const_source_x_2, '0', d20230403_hier_cos_angle_epb_0, '0']
- [analog_const_source_x_2, '0', d20230403_hier_sin_angle_epb_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_1, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_1, '0', pad_sink_1, '0']
- [d20230403_hier_cos_angle_epb_0, '0', blocks_float_to_complex_1, '0']
- [d20230403_hier_sin_angle_epb_0, '0', blocks_float_to_complex_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_1, '0']
- [pad_source_1, '0', d20230403_hier_cos_angle_epb_0, '0']
- [pad_source_1, '0', d20230403_hier_sin_angle_epb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
