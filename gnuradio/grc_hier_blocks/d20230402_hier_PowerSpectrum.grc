options:
  parameters:
    author: zzaw
    generate_options: hb
    id: d20230402_hier_PowerSpectrum
    output_language: python
    title: Power Spectrum
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/fft_size
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: fft_size
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: fft_size
    type: intx
    value: '32768'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: power_spectrum
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: float
    vlen: fft_size
  states: {}
- name: power_spectrum_dB
  id: pad_sink
  parameters:
    label: out_dB
    optional: 'True'
    type: float
    vlen: fft_size
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: 32e3
  states: {}
- name: sig_src
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', power_spectrum, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', power_spectrum_dB, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [sig_src, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
