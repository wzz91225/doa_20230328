options:
  parameters:
    author: zzaw
    category: '[DoA -  wzz91225]'
    description: '[0, pi/2] Single Narrowband  Signal'
    generate_options: hb
    id: d20230406_hier_DoA_2D_AmpComp_RMS
    output_language: python
    title: DoA - 2D - Amplitude Comparison - RMS
  states: {}

blocks:
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: d20230404_hier_atan2_epb_0
  id: d20230404_hier_atan2_epb
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: angle
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: ch1
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: ch2
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 32e3
  states: {}

connections:
- [blocks_rms_xx_0, '0', d20230404_hier_atan2_epb_0, '0']
- [blocks_rms_xx_1, '0', d20230404_hier_atan2_epb_0, '1']
- [d20230404_hier_atan2_epb_0, '1', blocks_null_sink_0, '0']
- [d20230404_hier_atan2_epb_0, '1', pad_sink_0, '0']
- [pad_source_0, '0', blocks_rms_xx_0, '0']
- [pad_source_1, '0', blocks_rms_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
