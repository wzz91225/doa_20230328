options:
  parameters:
    author: zzaw
    category: '[DoA -  wzz91225]'
    description: '[0, pi/2] Single Narrowband  Signal'
    generate_options: hb
    id: d20230406_hier_DoA_2D_AmpComp_PowerSpectrum
    output_language: python
    title: DoA - 2D - Amplitude Comparison - Power Spectrum
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: TH_Factor_Fall
  id: parameter
  parameters:
    hide: part
    type: eng_float
    value: '10'
  states: {}
- name: TH_Factor_Rise
  id: parameter
  parameters:
    hide: part
    type: eng_float
    value: '10'
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: d20230402_hier_PeriodicCenterFreqDetector_0
  id: d20230402_hier_PeriodicCenterFreqDetector
  parameters:
    TH_Factor_Fall: TH_Factor_Fall
    TH_Factor_Rise: TH_Factor_Rise
    fft_size: fft_size
    period_peak_detector: '1'
    samp_rate: samp_rate
  states: {}
- name: d20230402_hier_PeriodicCenterFreqDetector_1
  id: d20230402_hier_PeriodicCenterFreqDetector
  parameters:
    TH_Factor_Fall: TH_Factor_Fall
    TH_Factor_Rise: TH_Factor_Rise
    fft_size: fft_size
    period_peak_detector: '1'
    samp_rate: samp_rate
  states: {}
- name: d20230404_hier_atan2_epb_0
  id: d20230404_hier_atan2_epb
  parameters: {}
  states: {}
- name: d20230406_hier_sqrt_epb_0
  id: d20230406_hier_sqrt_epb
  parameters: {}
  states: {}
- name: d20230406_hier_sqrt_epb_1
  id: d20230406_hier_sqrt_epb
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: detected
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: freq_ch1
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: freq_ch2
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: angle
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: ch1
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: ch2
    type: complex
  states: {}
- name: period_peak_detector
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 32e3
  states: {}

connections:
- [blocks_and_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_and_xx_0, '0', pad_sink_0, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '0', blocks_and_xx_0, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '1', blocks_null_sink_1, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '1', pad_sink_1, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_0, '2', d20230406_hier_sqrt_epb_0, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_1, '0', blocks_and_xx_0, '1']
- [d20230402_hier_PeriodicCenterFreqDetector_1, '1', blocks_null_sink_2, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_1, '1', pad_sink_2, '0']
- [d20230402_hier_PeriodicCenterFreqDetector_1, '2', d20230406_hier_sqrt_epb_1, '0']
- [d20230404_hier_atan2_epb_0, '1', blocks_null_sink_3, '0']
- [d20230404_hier_atan2_epb_0, '1', pad_sink_3, '0']
- [d20230406_hier_sqrt_epb_0, '0', d20230404_hier_atan2_epb_0, '0']
- [d20230406_hier_sqrt_epb_1, '0', d20230404_hier_atan2_epb_0, '1']
- [pad_source_0, '0', d20230402_hier_PeriodicCenterFreqDetector_0, '0']
- [pad_source_1, '0', d20230402_hier_PeriodicCenterFreqDetector_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
