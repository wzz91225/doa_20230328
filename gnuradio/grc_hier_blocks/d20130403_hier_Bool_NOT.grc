options:
  parameters:
    author: zzaw
    generate_options: hb
    id: d20130403_hier_Bool_NOT
    output_language: python
    title: NOT (Byte Bool)
  states: {}

blocks:
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_xor_xx_1_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: NOT
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_1_0, '1']
- [blocks_xor_xx_1_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_xor_xx_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
