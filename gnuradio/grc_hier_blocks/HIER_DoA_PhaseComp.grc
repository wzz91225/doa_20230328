options:
  parameters:
    author: zzaw
    category: '[DoA -  wzz91225]'
    description: '[0, pi) Single Narrowband  Signal'
    generate_options: hb
    id: HIER_DoA_PhaseComp
    output_language: python
    title: DoA - PhaseComp
  states: {}

blocks:
- name: aoa_calc_phase_diff_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: c
  id: parameter
  parameters:
    type: eng_float
    value: '299792458'
  states: {}
- name: delta_d
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, pi=3.141592653589793, c=299792458, frequency=0, delta_d=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.pi = pi
              self.c = c
              self.frequency = frequency
              self.delta_d = delta_d

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              alpha = np.arccos(input_items[0] * self.c / self.frequency / 2 / self.pi / self.delta_d)
              output_items[0][:] = alpha
              output_items[1][:] = np.rad2deg(alpha)
              return len(output_items[0])
    c: c
    delta_d: delta_d
    frequency: frequency
    pi: pi
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: rad
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: deg
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: ch1
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: ch2
    type: complex
  states: {}
- name: pi
  id: parameter
  parameters:
    type: eng_float
    value: '3.141592653589793'
  states: {}

connections:
- [aoa_calc_phase_diff_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', pad_sink_0, '0']
- [epy_block_0, '1', blocks_null_sink_0_0, '0']
- [epy_block_0, '1', pad_sink_0_0, '0']
- [pad_source_0, '0', aoa_calc_phase_diff_0, '0']
- [pad_source_1, '0', aoa_calc_phase_diff_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
