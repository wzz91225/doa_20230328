options:
  parameters:
    author: zzaw
    description: input - angle
    generate_options: hb
    id: d20230403_hier_sin_angle_epb
    output_language: python
    title: sin - angle (epb)
  states: {}

blocks:
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='sin - angle (epb)',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.sin(input_items[0] * np.pi / 180)
              return len(output_items[0])
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: sind
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [epy_block_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
