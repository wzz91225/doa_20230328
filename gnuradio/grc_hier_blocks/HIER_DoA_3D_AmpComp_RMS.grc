options:
  parameters:
    author: zzaw
    category: '[DoA -  wzz91225]'
    description: Both [0, pi/2] - Single Narrowband  Signal
    generate_options: hb
    id: HIER_DoA_3D_AmpComp_RMS
    output_language: python
    title: DoA - 3D - Amplitude Comparison - RMS
  states: {}

blocks:
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_2
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Amplitude Comparison - 3D(angle)',   # will show up in GRC
                  in_sig=[np.float32, np.float32, np.float32],
                  out_sig=[np.float32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.rad2deg(np.arctan2(input_items[1], input_items[0]))
              # output_items[1][:] = np.rad2deg(np.arctan2(input_items[2], \
              #                                            np.sqrt(np.square(input_items[0]) + np.square(input_items[1]))))
              output_items[1][:] = np.rad2deg(np.arctan2(np.sqrt(np.square(input_items[0]) + np.square(input_items[1])), \
                                                         input_items[2]))
              return len(output_items[0])
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: azimuth
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: pitch
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: ch1
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: ch2
    type: complex
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: ch3
    type: complex
  states: {}

connections:
- [blocks_rms_xx_0, '0', epy_block_0, '0']
- [blocks_rms_xx_1, '0', epy_block_0, '1']
- [blocks_rms_xx_2, '0', epy_block_0, '2']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', pad_sink_0, '0']
- [epy_block_0, '1', blocks_null_sink_1, '0']
- [epy_block_0, '1', pad_sink_1, '0']
- [pad_source_0, '0', blocks_rms_xx_0, '0']
- [pad_source_1, '0', blocks_rms_xx_1, '0']
- [pad_source_2, '0', blocks_rms_xx_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
