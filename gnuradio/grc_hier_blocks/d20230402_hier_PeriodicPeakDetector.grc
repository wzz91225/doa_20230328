options:
  parameters:
    author: zzaw
    generate_options: hb
    id: d20230402_hier_PeriodicPeakDetector
    output_language: python
    title: Periodic Peak Detector
  states: {}

blocks:
- name: TH_Factor_Fall
  id: parameter
  parameters:
    label: TH_Factor_Fall
    type: eng_float
    value: '0.4'
  states: {}
- name: TH_Factor_Rise
  id: parameter
  parameters:
    label: TH_Factor_Rise
    type: eng_float
    value: '0.25'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1/period_peak_detector
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_peak_detector_xb_0_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '20'
    threshold_factor_fall: TH_Factor_Fall
    threshold_factor_rise: TH_Factor_Rise
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: period_peak_detector
  id: parameter
  parameters:
    label: period_peak_detector
    type: eng_float
    value: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: 32e3
  states: {}
- name: vsink_sigsrc_updating_sign
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: vsrc_sigsrc_updating_sign
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_1_0, '0']
- [analog_sig_source_x_1, '0', blocks_xor_xx_1_0, '1']
- [analog_sig_source_x_1, '0', vsink_sigsrc_updating_sign, '0']
- [blocks_peak_detector_xb_0_0, '0', blocks_sample_and_hold_xx_0_1_1, '0']
- [blocks_peak_detector_xb_0_0, '0', blocks_xor_xx_1, '0']
- [blocks_sample_and_hold_xx_0_1_1, '0', blocks_sample_and_hold_xx_0_1_1_0, '0']
- [blocks_sample_and_hold_xx_0_1_1_0, '0', pad_sink_0, '0']
- [blocks_xor_xx_1, '0', blocks_sample_and_hold_xx_0_1_1, '1']
- [blocks_xor_xx_1_0, '0', blocks_xor_xx_1, '1']
- [pad_source_0, '0', blocks_peak_detector_xb_0_0, '0']
- [vsrc_sigsrc_updating_sign, '0', blocks_sample_and_hold_xx_0_1_1_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
