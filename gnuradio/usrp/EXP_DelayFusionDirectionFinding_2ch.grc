options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: EXP_DelayFusionDirectionFinding_2ch
    output_language: python
    title: Experiment - Delay Fusion Direction Finding
  states: {}

blocks:
- name: TH_Factor_Fall
  id: variable_qtgui_range
  parameters:
    gui_hint: sink3+1, 3, 1, 1
    start: '1e-2'
    step: '1e-2'
    stop: 1e3
    value: '100'
  states: {}
- name: TH_Factor_Rise
  id: variable_qtgui_range
  parameters:
    gui_hint: sink3+1, 2, 1, 1
    start: '1e-2'
    step: '1e-2'
    stop: 1e3
    value: '100'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: delay_1
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+1, 0, 1, 2
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: delay_2
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+1, 2, 1, 2
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: frequency_detecting
  id: variable_qtgui_range
  parameters:
    gui_hint: sink3+1, 0, 1, 2
    start: '1e-1'
    step: '1e-1'
    stop: 1e3
    value: '1'
  states: {}
- name: gain_rx1
  id: variable_qtgui_range
  parameters:
    gui_hint: sink1+1, 0, 1, 2
    start: '0'
    step: '1'
    stop: '93'
    value: '40'
  states: {}
- name: gain_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: sink1+1, 2, 1, 2
    start: '0'
    step: '1'
    stop: '93'
    value: '41'
  states: {}
- name: multiply_1
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+2, 0, 1, 2
    start: '0.5'
    step: '1e-3'
    stop: '1.5'
    value: '1'
  states: {}
- name: multiply_2
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+2, 2, 1, 2
    start: '0.5'
    step: '1e-3'
    stop: '1.5'
    value: '0.832'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e5
  states: {}
- name: sink1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sink1_max
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sink2
  id: variable
  parameters:
    value: sink1+sink1_max
  states: {}
- name: sink2_max
  id: variable
  parameters:
    value: '5'
  states: {}
- name: sink3
  id: variable
  parameters:
    value: sink2+sink2_max
  states: {}
- name: sink3_max
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sink4
  id: variable
  parameters:
    value: sink3+sink3_max
  states: {}
- name: sink4_max
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sink5
  id: variable
  parameters:
    value: sink4+sink4_max
  states: {}
- name: sink5_max
  id: variable
  parameters:
    value: '1'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: sink1,0,1,4
    label: '"NI ETTUS USRP X310 with Dual TWINRX"'
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    gui_hint: sink2,0,1,4
    label: '"2 RX Channels Calibrating"'
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_2
  id: variable_qtgui_label
  parameters:
    gui_hint: sink3,0,1,4
    label: '"Period Frequency Detecting"'
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_3
  id: variable_qtgui_label
  parameters:
    gui_hint: sink4,0,1,4
    label: '"Direction Finding - Amplitude Comparison"'
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_4
  id: variable_qtgui_label
  parameters:
    gui_hint: sink5,0,1,4
    label: '"Delay Semi-Sim"'
    type: string
    value: ''
  states: {}
- name: HIER_complex2float_0
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_1
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency_detecting
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: aoa_calc_phase_diff_1
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_argmax_xx_0_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_1
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: '0'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: delay_2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/fft_size
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/fft_size
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_1
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/fft_size
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/fft_size
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_2
    type: complex
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_peak_detector_xb_0_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '20'
    threshold_factor_fall: TH_Factor_Fall
    threshold_factor_rise: TH_Factor_Rise
    type: float
  states: {}
- name: blocks_peak_detector_xb_0_0_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '20'
    threshold_factor_fall: TH_Factor_Fall
    threshold_factor_rise: TH_Factor_Rise
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1_0_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1_1
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_var_to_msg_1_0
  id: blocks_var_to_msg
  parameters:
    msgname: frequency
    target: frequency
  states: {state: disabled}
- name: blocks_var_to_msg_1_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: dis_r
    target: distance_relative
  states: {state: disabled}
- name: blocks_var_to_msg_1_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: DoA
    target: relative_DoA
  states: {state: disabled}
- name: blocks_var_to_msg_1_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: v_t
    target: velocity_t
  states: {state: disabled}
- name: blocks_var_to_msg_1_0_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: delta_t
    target: Delta_t
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_xor_xx_1
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1_1
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block - 从给定向量中根据指定下标提取元素"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Selective Keep (EPB)',   # will show up in GRC
                  in_sig=[(np.float32, 2048), np.int16],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              """Selective Keep"""
              
              vec = input_items[0][0]  # 获取向量
              idx = int(input_items[1][0])  # 获取下标并转换为整数
              output_items[0][:] = [vec[idx]]  # 根据下标提取元素并赋值给输出

              return 1
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block - 从给定向量中根据指定下标提取元素"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Selective Keep (EPB)',   # will show up in GRC
                  in_sig=[(np.float32, 2048), np.int16],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              """Selective Keep"""
              
              vec = input_items[0][0]  # 获取向量
              idx = int(input_items[1][0])  # 获取下标并转换为整数
              output_items[0][:] = [vec[idx]]  # 根据下标提取元素并赋值给输出

              return 1
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    DoA: relative_DoA
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=32e3, pi=3.14159, c=299.792e6, frequency=0, dis_r=0, DoA=0, v_t=0, delta_t=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='delay_calc(epb)',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.samp_rate = samp_rate
              self.pi = pi
              self.c = c

              self.frequency = frequency
              self.dis_r = dis_r
              self.DoA = DoA
              self.v_t = v_t
              self.delta_t = delta_t

              # 注册消息端口
              self.message_port_register_in(pmt.intern("update_params"))
              self.set_msg_handler(pmt.intern("update_params"), self.handle_msg)

              self.message_port_register_out(pmt.intern('delay_B'))
              self.message_port_register_out(pmt.intern('delay_A'))
          

          def handle_msg(self, msg):
              # 解析消息并更新参数
              if pmt.is_pair(msg):
                  key = pmt.to_python(pmt.car(msg))
                  value = pmt.to_python(pmt.cdr(msg))
                  print(key, value)

                  if key == "frequency":
                      self.frequency = value
                  elif key == "dis_r":
                      self.dis_r = value
                  elif key == "DoA":
                      self.DoA = value
                  elif key == "v_t":
                      self.v_t = value
                  elif key == "delta_t":
                      self.delta_t = value

                  # compute
                  alpha_sin = np.sin(self.DoA * self.pi / 180)
                  alpha_cos = np.cos(self.DoA * self.pi / 180)
                  dis_at = self.v_t * self.delta_t
                  distance_A = np.sqrt((self.dis_r * alpha_cos - dis_at/2)**2 + (self.dis_r * alpha_sin)**2)
                  distance_B = np.sqrt((self.dis_r * alpha_cos + dis_at/2)**2 + (self.dis_r * alpha_sin)**2)
                  delay_A = int((distance_A / self.c) * self.samp_rate)
                  delay_B = int((distance_B / self.c + self.delta_t) * self.samp_rate)

                  self.message_port_pub(pmt.intern("delay_A"), pmt.from_long(delay_A))
                  self.message_port_pub(pmt.intern("delay_B"), pmt.from_long(delay_B))
                  print(distance_A, distance_B)
                  print(delay_A, delay_B)


          # def work(self, input_items, output_items):
          #     """"""
          #     return len(output_items[0])
    c: c
    delta_t: Delta_t
    dis_r: distance_relative
    frequency: frequency
    pi: pi
    samp_rate: samp_rate
    v_t: velocity_t
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='DF2D: Amplitude Comparison (EPB)',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              """DF2D: Amplitude Comparison"""

              x = np.sqrt(input_items[0]);
              y = np.sqrt(input_items[1])
              radian = np.arctan2(x, y);
              output_items[0][:] = radian * 180 / np.pi;

              return len(output_items[0])
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: sink2+4, 2, 1, 2
    label1: '"RX1 & RX2"'
    max: pi
    min: '-pi'
    name: '"RX Phase Differences"'
    type: float
    unit1: '"Angle"'
    update_time: '0.5'
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: sink2+4, 0, 1, 2
    min: '0'
    name: '"RX Magnitude"'
    nconnections: '2'
    type: float
    update_time: '0.50'
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: sink3+3, 1, 1, 3
    label1: '"Signal 1 Frequency"'
    label2: '"Signal 2 Frequency"'
    label3: '"Signal 1 Mag^2"'
    label4: '"Signal 2 Mag^2"'
    name: '"Signal Detected"'
    nconnections: '4'
    type: float
    unit1: '"Hz"'
    unit2: '"Hz"'
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: sink3+3, 0, 1, 1
    label1: '"RX 1 (0: Undetected; 1:Detected)"'
    label2: '"RX 2 (0: Undetected; 1:Detected)"'
    min: '0'
    name: '"Detecting Status"'
    nconnections: '2'
    type: byte
    unit2: '"Bool"'
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: sink4+1, 0, 1, 4
    max: '180'
    min: '0'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: sink1+2,0,1,2
    name: '"Signal RX1"'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: sink1+2,2,1,2
    name: '"Signal RX2"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: sink2+3, 0, 1, 2
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: sink2+3, 2, 1, 2
    name: '"RX Phase"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.25'
    ylabel: Phase
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: sink3+2, 0, 1, 2
    update_time: '0.5'
    vlen: fft_size
    x_axis_label: '"Frequency (kHz)"'
    x_start: '0'
    x_step: samp_rate/fft_size/1e3
    y_axis_label: '"Amplitude (dB)"'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: sink3+2, 2, 1, 2
    update_time: '0.5'
    vlen: fft_size
    x_axis_label: '"Frequency (kHz)"'
    x_start: '0'
    x_step: samp_rate/fft_size/1e3
    y_axis_label: '"Amplitude (dB)"'
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    gain0: gain_rx1
    gain1: gain_rx2
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RX_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RXCali_1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RX_2
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: RXCali_2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: PSpectrum_1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: PSpectrum_2
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: TriggerSig_detecting
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: TriggerSig_detecting_NOT
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: detected_1
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: detected_2
  states: {}
- name: virtual_sink_5_0_0
  id: virtual_sink
  parameters:
    stream_id: signal_2_MagSquared
  states: {}
- name: virtual_sink_5_1
  id: virtual_sink
  parameters:
    stream_id: signal_1_MagSquared
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TriggerSig_detecting
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: TriggerSig_detecting
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: RX_1
  states: {}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: RXCali_1
  states: {}
- name: virtual_source_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_1
  states: {}
- name: virtual_source_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: PSpectrum_1
  states: {}
- name: virtual_source_0_0_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: PSpectrum_1
  states: {}
- name: virtual_source_0_0_0_1_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: PSpectrum_1
  states: {}
- name: virtual_source_0_0_0_1_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: PSpectrum_2
  states: {}
- name: virtual_source_0_0_0_1_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: signal_2_MagSquared
  states: {}
- name: virtual_source_0_0_0_1_0_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: signal_1_MagSquared
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: TriggerSig_detecting_NOT
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: TriggerSig_detecting_NOT
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX_2
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_2
  states: {}
- name: virtual_source_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_2
  states: {}
- name: virtual_source_1_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: PSpectrum_2
  states: {}
- name: virtual_source_1_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: PSpectrum_2
  states: {}

connections:
- [HIER_complex2float_0, '0', qtgui_time_sink_x_0, '0']
- [HIER_complex2float_1, '0', qtgui_time_sink_x_0, '1']
- [analog_const_source_x_0, '0', blocks_xor_xx_1_0, '0']
- [analog_sig_source_x_1, '0', blocks_xor_xx_1_0, '1']
- [analog_sig_source_x_1, '0', virtual_sink_4, '0']
- [aoa_calc_phase_diff_1, '0', qtgui_number_sink_0, '0']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '0', epy_block_0, '1']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_argmax_xx_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_argmax_xx_0_0, '0', epy_block_0_0, '1']
- [blocks_argmax_xx_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_2, '0']
- [blocks_complex_to_mag_squared_0_0, '0', virtual_sink_3, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_number_sink_1, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_magphase_1, '0', qtgui_number_sink_1, '1']
- [blocks_complex_to_magphase_1, '1', qtgui_time_sink_x_0_1, '1']
- [blocks_delay_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_delay_1, '0', blocks_multiply_const_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_2, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_number_sink_2, '1']
- [blocks_multiply_const_xx_0, '0', HIER_complex2float_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_xx_0_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_multiply_const_xx_1, '0', HIER_complex2float_1, '0']
- [blocks_multiply_const_xx_1, '0', virtual_sink_1_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_0_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_peak_detector_xb_0_0, '0', blocks_sample_and_hold_xx_0_1_1, '0']
- [blocks_peak_detector_xb_0_0, '0', blocks_xor_xx_1, '0']
- [blocks_peak_detector_xb_0_0_0, '0', blocks_sample_and_hold_xx_0_1_1_1, '0']
- [blocks_peak_detector_xb_0_0_0, '0', blocks_xor_xx_1_1, '0']
- [blocks_sample_and_hold_xx_0_1_1, '0', blocks_sample_and_hold_xx_0_1_1_0, '0']
- [blocks_sample_and_hold_xx_0_1_1_0, '0', qtgui_number_sink_3, '0']
- [blocks_sample_and_hold_xx_0_1_1_0, '0', virtual_sink_5, '0']
- [blocks_sample_and_hold_xx_0_1_1_0_0, '0', qtgui_number_sink_3, '1']
- [blocks_sample_and_hold_xx_0_1_1_0_0, '0', virtual_sink_5_0, '0']
- [blocks_sample_and_hold_xx_0_1_1_1, '0', blocks_sample_and_hold_xx_0_1_1_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_var_to_msg_1_0, msgout, epy_block_0_1, update_params]
- [blocks_var_to_msg_1_0_0, msgout, epy_block_0_1, update_params]
- [blocks_var_to_msg_1_0_0_0, msgout, epy_block_0_1, update_params]
- [blocks_var_to_msg_1_0_0_0_0, msgout, epy_block_0_1, update_params]
- [blocks_var_to_msg_1_0_0_0_0_0, msgout, epy_block_0_1, update_params]
- [blocks_vector_to_stream_0, '0', blocks_peak_detector_xb_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_peak_detector_xb_0_0_0, '0']
- [blocks_xor_xx_1, '0', blocks_sample_and_hold_xx_0_1_1, '1']
- [blocks_xor_xx_1_0, '0', virtual_sink_4_0, '0']
- [blocks_xor_xx_1_1, '0', blocks_sample_and_hold_xx_0_1_1_1, '1']
- [epy_block_0, '0', qtgui_number_sink_2, '2']
- [epy_block_0, '0', virtual_sink_5_1, '0']
- [epy_block_0_0, '0', qtgui_number_sink_2, '3']
- [epy_block_0_0, '0', virtual_sink_5_0_0, '0']
- [epy_block_0_1, delay_A, blocks_delay_0_1, dly]
- [epy_block_0_1, delay_B, blocks_delay_0_0, dly]
- [epy_block_1, '0', qtgui_number_sink_4, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_const_xx_0_0_0, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_1, '0', virtual_sink_0, '0']
- [uhd_usrp_source_1, '1', qtgui_sink_x_1, '0']
- [uhd_usrp_source_1, '1', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_sample_and_hold_xx_0_1_1_0, '1']
- [virtual_source_0_0, '0', blocks_sample_and_hold_xx_0_1_1_0_0, '1']
- [virtual_source_0_0_0_1, '0', blocks_delay_0, '0']
- [virtual_source_0_0_0_1_0, '0', aoa_calc_phase_diff_1, '0']
- [virtual_source_0_0_0_1_0, '0', blocks_complex_to_magphase_0, '0']
- [virtual_source_0_0_0_1_0_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0_0_1_0_0_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0_0_0_1_0_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [virtual_source_0_0_0_1_0_0_0_1, '0', blocks_argmax_xx_0, '0']
- [virtual_source_0_0_0_1_0_0_0_1, '0', epy_block_0, '0']
- [virtual_source_0_0_0_1_0_0_0_1_0, '0', blocks_argmax_xx_0_0, '0']
- [virtual_source_0_0_0_1_0_0_0_1_0, '0', epy_block_0_0, '0']
- [virtual_source_0_0_0_1_0_0_0_1_0_0, '0', epy_block_1, '1']
- [virtual_source_0_0_0_1_0_0_0_1_1, '0', epy_block_1, '0']
- [virtual_source_0_1, '0', blocks_xor_xx_1, '1']
- [virtual_source_0_1_0, '0', blocks_xor_xx_1_1, '1']
- [virtual_source_1_0_0_0, '0', blocks_delay_1, '0']
- [virtual_source_1_0_0_0_0, '0', aoa_calc_phase_diff_1, '1']
- [virtual_source_1_0_0_0_0, '0', blocks_complex_to_magphase_1, '0']
- [virtual_source_1_0_0_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_1_0_0_0_0_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [virtual_source_1_0_0_0_0_0_0_0, '0', blocks_nlog10_ff_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
