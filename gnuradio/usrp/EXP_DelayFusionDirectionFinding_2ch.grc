options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: EXP_DelayFusionDirectionFinding_2ch
    output_language: python
    title: Experiment - Delay Fusion Direction Finding
  states: {}

blocks:
- name: TH_Factor_Fall
  id: variable_qtgui_range
  parameters:
    gui_hint: sink3+1, 3, 1, 1
    start: '1e-2'
    step: '1e-2'
    stop: 1e3
    value: '100'
  states: {}
- name: TH_Factor_Rise
  id: variable_qtgui_range
  parameters:
    gui_hint: sink3+1, 2, 1, 1
    start: '1e-2'
    step: '1e-2'
    stop: 1e3
    value: '100'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: delay_1
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+1, 0, 1, 2
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: delay_2
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+1, 2, 1, 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: frequency_detecting
  id: variable_qtgui_range
  parameters:
    gui_hint: sink3+1, 0, 1, 2
    start: '1e-1'
    step: '1e-1'
    stop: 1e3
    value: '1'
  states: {}
- name: gain_rx1
  id: variable_qtgui_range
  parameters:
    gui_hint: sink1+1, 0, 1, 2
    start: '0'
    step: '1'
    stop: '93'
    value: '40'
  states: {}
- name: gain_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: sink1+1, 2, 1, 2
    start: '0'
    step: '1'
    stop: '93'
    value: '41'
  states: {}
- name: multiply_1
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+2, 0, 1, 2
    start: '0.5'
    step: '1e-3'
    stop: '1.5'
    value: '1'
  states: {}
- name: multiply_2
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+2, 2, 1, 1
    start: '0.5'
    step: '1e-3'
    stop: '1.5'
    value: '0.832'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e5
  states: {}
- name: sink1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sink1_max
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sink2
  id: variable
  parameters:
    value: sink1+sink1_max
  states: {}
- name: sink2_max
  id: variable
  parameters:
    value: '5'
  states: {}
- name: sink3
  id: variable
  parameters:
    value: sink2+sink2_max
  states: {}
- name: sink3_max
  id: variable
  parameters:
    value: '2'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: sink1,0,1,4
    label: '"NI ETTUS USRP X310 with Dual TWINRX"'
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    gui_hint: sink2,0,1,4
    label: '"2 RX Channels Calibrating"'
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_2
  id: variable_qtgui_label
  parameters:
    gui_hint: sink3,0,1,4
    label: '"Period Frequency Detecting"'
    type: string
    value: ''
  states: {}
- name: HIER_complex2float_0
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_1
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency_detecting
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: aoa_calc_phase_diff_1
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_1
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: delay_2
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_1
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/fft_size
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/fft_size
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_2
    type: complex
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_peak_detector_xb_0_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '20'
    threshold_factor_fall: TH_Factor_Fall
    threshold_factor_rise: TH_Factor_Rise
    type: float
  states: {}
- name: blocks_peak_detector_xb_0_0_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '20'
    threshold_factor_fall: TH_Factor_Fall
    threshold_factor_rise: TH_Factor_Rise
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1_0_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_sample_and_hold_xx_0_1_1_1
  id: blocks_sample_and_hold_xx
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_xor_xx_1
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1_1
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: sink2+4, 2, 1, 2
    label1: '"RX1 & RX2"'
    max: pi
    min: '-pi'
    name: '"RX Phase Differences"'
    type: float
    unit1: '"Angle"'
    update_time: '0.5'
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: sink2+4, 0, 1, 2
    min: '0'
    name: '"RX Magnitude"'
    nconnections: '2'
    type: float
    update_time: '0.50'
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: RX 1 Detected
    label2: RX 2 Detected
    min: '0'
    name: '"Signals Detected"'
    nconnections: '2'
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: sink1+2,0,1,2
    name: '"Signal RX1"'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: sink1+2,2,1,2
    name: '"Signal RX2"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: sink2+3, 0, 1, 2
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: sink2+3, 2, 1, 2
    name: '"RX Phase"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.25'
    ylabel: Phase
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    update_time: '0.5'
    vlen: fft_size
    x_axis_label: '"Frequency (kHz)"'
    x_start: '0'
    x_step: samp_rate/fft_size/1e3
    y_axis_label: '"Amplitude"'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    update_time: '0.5'
    vlen: fft_size
    x_axis_label: '"Frequency (kHz)"'
    x_start: '0'
    x_step: samp_rate/fft_size/1e3
    y_axis_label: '"Amplitude"'
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    gain0: gain_rx1
    gain1: gain_rx2
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RX_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RXCali_1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RX_2
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: RXCali_2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: PSpectrum_1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: PSpectrum_2
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: TriggerSig_detecting
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: TriggerSig_detecting_NOT
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TriggerSig_detecting
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: TriggerSig_detecting
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: RX_1
  states: {}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: RXCali_1
  states: {}
- name: virtual_source_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_1
  states: {}
- name: virtual_source_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: PSpectrum_1
  states: {}
- name: virtual_source_0_0_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: PSpectrum_1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: TriggerSig_detecting_NOT
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: TriggerSig_detecting_NOT
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX_2
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_2
  states: {}
- name: virtual_source_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_2
  states: {}
- name: virtual_source_1_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: PSpectrum_2
  states: {}
- name: virtual_source_1_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: PSpectrum_2
  states: {}

connections:
- [HIER_complex2float_0, '0', qtgui_time_sink_x_0, '0']
- [HIER_complex2float_1, '0', qtgui_time_sink_x_0, '1']
- [analog_const_source_x_0, '0', blocks_xor_xx_1_0, '0']
- [analog_sig_source_x_1, '0', blocks_xor_xx_1_0, '1']
- [analog_sig_source_x_1, '0', virtual_sink_4, '0']
- [aoa_calc_phase_diff_1, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_2, '0']
- [blocks_complex_to_mag_squared_0_0, '0', virtual_sink_3, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_number_sink_1, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_magphase_1, '0', qtgui_number_sink_1, '1']
- [blocks_complex_to_magphase_1, '1', qtgui_time_sink_x_0_1, '1']
- [blocks_delay_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_delay_1, '0', blocks_multiply_const_xx_1, '0']
- [blocks_multiply_const_xx_0, '0', HIER_complex2float_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_xx_0_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_multiply_const_xx_1, '0', HIER_complex2float_1, '0']
- [blocks_multiply_const_xx_1, '0', virtual_sink_1_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_0_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_peak_detector_xb_0_0, '0', blocks_sample_and_hold_xx_0_1_1, '0']
- [blocks_peak_detector_xb_0_0, '0', blocks_xor_xx_1, '0']
- [blocks_peak_detector_xb_0_0_0, '0', blocks_sample_and_hold_xx_0_1_1_1, '0']
- [blocks_peak_detector_xb_0_0_0, '0', blocks_xor_xx_1_1, '0']
- [blocks_sample_and_hold_xx_0_1_1, '0', blocks_sample_and_hold_xx_0_1_1_0, '0']
- [blocks_sample_and_hold_xx_0_1_1_0, '0', qtgui_number_sink_3, '0']
- [blocks_sample_and_hold_xx_0_1_1_0_0, '0', qtgui_number_sink_3, '1']
- [blocks_sample_and_hold_xx_0_1_1_1, '0', blocks_sample_and_hold_xx_0_1_1_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_peak_detector_xb_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_peak_detector_xb_0_0_0, '0']
- [blocks_xor_xx_1, '0', blocks_sample_and_hold_xx_0_1_1, '1']
- [blocks_xor_xx_1_0, '0', virtual_sink_4_0, '0']
- [blocks_xor_xx_1_1, '0', blocks_sample_and_hold_xx_0_1_1_1, '1']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_const_xx_0_0_0, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_1, '0', virtual_sink_0, '0']
- [uhd_usrp_source_1, '1', qtgui_sink_x_1, '0']
- [uhd_usrp_source_1, '1', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_sample_and_hold_xx_0_1_1_0, '1']
- [virtual_source_0_0, '0', blocks_sample_and_hold_xx_0_1_1_0_0, '1']
- [virtual_source_0_0_0_1, '0', blocks_delay_0, '0']
- [virtual_source_0_0_0_1_0, '0', aoa_calc_phase_diff_1, '0']
- [virtual_source_0_0_0_1_0, '0', blocks_complex_to_magphase_0, '0']
- [virtual_source_0_0_0_1_0_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0_0_1_0_0_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0_0_0_1_0_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [virtual_source_0_1, '0', blocks_xor_xx_1, '1']
- [virtual_source_0_1_0, '0', blocks_xor_xx_1_1, '1']
- [virtual_source_1_0_0_0, '0', blocks_delay_1, '0']
- [virtual_source_1_0_0_0_0, '0', aoa_calc_phase_diff_1, '1']
- [virtual_source_1_0_0_0_0, '0', blocks_complex_to_magphase_1, '0']
- [virtual_source_1_0_0_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_1_0_0_0_0_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [virtual_source_1_0_0_0_0_0_0_0, '0', blocks_nlog10_ff_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
