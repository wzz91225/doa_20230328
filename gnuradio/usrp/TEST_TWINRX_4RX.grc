options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: TEST_4RX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: gain_rx_A0
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0
    start: '0'
    step: '1'
    stop: '93'
    value: '1'
  states: {}
- name: gain_rx_A1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 1
    start: '0'
    step: '1'
    stop: '93'
    value: '2'
  states: {}
- name: gain_rx_B0
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 0
    start: '0'
    step: '1'
    stop: '93'
    value: '3'
  states: {}
- name: gain_rx_B1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 1
    start: '0'
    step: '1'
    stop: '93'
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_2_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_2_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0, 0
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    type: complex
  states: {}
- name: qtgui_sink_x_0_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_3
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_3_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX1
    center_freq0: center_freq
    gain0: gain_rx_A0
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    gain0: gain_rx_A1
    samp_rate: samp_rate
    sd_spec0: A:1
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    gain0: gain_rx_B1
    samp_rate: samp_rate
    sd_spec0: B:1
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    ant1: '"RX2"'
    ant2: '"RX1"'
    ant3: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    bw2: samp_rate
    bw3: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    gain0: gain_rx_A0
    gain1: gain_rx_A1
    gain2: gain_rx_B0
    gain3: gain_rx_B1
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: A:0 A:1 B:0 B:1
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_2
  id: uhd_usrp_source
  parameters:
    ant0: RX1
    center_freq0: center_freq
    gain0: gain_rx_B0
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    gain0: gain_rx_A0
    gain1: gain_rx_B1
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: A:0 B:1
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    ant2: ''
    bw0: samp_rate
    bw1: samp_rate
    bw2: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    gain0: gain_rx_A1
    gain1: gain_rx_B0
    gain2: gain_rx_B1
    nchan: '3'
    rx_agc2: Default
    samp_rate: samp_rate
    sd_spec0: A:1 B:0 B:1
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_sink_x_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', qtgui_sink_x_0_0_1, '0']
- [uhd_usrp_source_0_1, '0', qtgui_sink_x_0_1, '0']
- [uhd_usrp_source_0_1, '1', qtgui_sink_x_0_0_0, '0']
- [uhd_usrp_source_0_1, '2', qtgui_sink_x_0_1_0, '0']
- [uhd_usrp_source_0_1, '3', qtgui_sink_x_0_0_0_0, '0']
- [uhd_usrp_source_0_2, '0', qtgui_sink_x_0_2, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_0_3, '0']
- [uhd_usrp_source_1, '1', qtgui_sink_x_0_0_2, '0']
- [uhd_usrp_source_1_0, '0', qtgui_sink_x_0_3_0, '0']
- [uhd_usrp_source_1_0, '1', qtgui_sink_x_0_0_2_0, '0']
- [uhd_usrp_source_1_0, '2', qtgui_sink_x_0_0_2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
