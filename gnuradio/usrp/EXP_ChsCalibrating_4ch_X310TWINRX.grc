options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: EXP_ChsCalibrating_4ch_X310TWINRX
    output_language: python
    title: Multiple Channels Calibradting Experiment
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: delay_1
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+1, 0, 1, 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: delay_2
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+1, 1, 1, 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: delay_3
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+1, 2, 1, 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: delay_4
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+1, 3, 1, 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: gain_rx1
  id: variable_qtgui_range
  parameters:
    gui_hint: sink1+1, 0
    start: '0'
    step: '1'
    stop: '93'
    value: '40'
  states: {}
- name: gain_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: sink1+1, 1
    start: '0'
    step: '1'
    stop: '93'
    value: '41'
  states: {}
- name: gain_rx3
  id: variable_qtgui_range
  parameters:
    gui_hint: sink1+1, 2
    start: '0'
    step: '1'
    stop: '93'
    value: '39'
  states: {}
- name: gain_rx4
  id: variable_qtgui_range
  parameters:
    gui_hint: sink1+1, 3
    start: '0'
    step: '1'
    stop: '93'
    value: '41'
  states: {}
- name: multiply_1
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+2, 0, 1, 1
    start: '0.5'
    step: '1e-3'
    stop: '1.5'
    value: '1'
  states: {}
- name: multiply_2
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+2, 1, 1, 1
    start: '0.5'
    step: '1e-3'
    stop: '1.5'
    value: '1.02'
  states: {}
- name: multiply_3
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+2, 2, 1, 1
    start: '0.5'
    step: '1e-3'
    stop: '1.5'
    value: '1.049'
  states: {}
- name: multiply_4
  id: variable_qtgui_range
  parameters:
    gui_hint: sink2+2, 3, 1, 1
    start: '0.5'
    step: '1e-3'
    stop: '1.5'
    value: '0.974'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e5
  states: {}
- name: sink1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sink1_max
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sink2
  id: variable
  parameters:
    value: sink1+sink1_max
  states: {}
- name: sink2_max
  id: variable
  parameters:
    value: '5'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: sink1,0,1,4
    label: '"NI ETTUS USRP X310 with Dual TWINRX"'
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    gui_hint: sink2,0,1,4
    label: '"4 RX Channels Calibrating"'
    type: string
    value: ''
  states: {}
- name: HIER_complex2float_0
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_1
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_2
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_3
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: aoa_calc_phase_diff_1
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: aoa_calc_phase_diff_1_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: aoa_calc_phase_diff_1_1
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_2
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_3
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_1
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_3
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: delay_2
    type: complex
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: delay_4
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_1
    type: complex
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_2
    type: complex
  states: {}
- name: blocks_multiply_const_xx_2
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_3
    type: complex
  states: {}
- name: blocks_multiply_const_xx_3
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_4
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: sink2+4, 2, 1, 2
    label1: '"RX1 & RX2"'
    label2: '"RX1 & RX3"'
    label3: '"RX1 & RX4"'
    max: pi
    min: '-pi'
    name: '"RX Phase Differences"'
    nconnections: '3'
    type: float
    unit1: '"Angle"'
    unit2: '"Angle"'
    unit3: '"Angle"'
    update_time: '0.5'
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: sink2+4, 0, 1, 2
    min: '0'
    name: '"RX Magnitude"'
    nconnections: '4'
    type: float
    update_time: '0.50'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: sink1+2,0,1,2
    name: '"Signal RX1"'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: sink1+2,2,1,2
    name: '"Signal RX2"'
    type: complex
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: sink1+3,2,1,2
    name: '"Signal RX4"'
    type: complex
  states: {}
- name: qtgui_sink_x_3
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: sink1+3,0,1,2
    name: '"Signal RX3"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: sink2+3, 0, 1, 2
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: sink2+3, 2, 1, 2
    name: '"RX Phase"'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.25'
    ylabel: Phase
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    ant1: '"RX2"'
    ant2: '"RX1"'
    ant3: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    bw2: samp_rate
    bw3: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    gain0: gain_rx1
    gain1: gain_rx2
    gain2: gain_rx3
    gain3: gain_rx4
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RX_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RXCali_1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RX_2
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: RXCali_2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RX_3
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: RXCali_3
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: RX_4
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: RXCali_4
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: RX_1
  states: {}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: RXCali_1
  states: {}
- name: virtual_source_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: RX_3
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_3
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_3
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX_2
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_2
  states: {}
- name: virtual_source_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_2
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: RX_4
  states: {}
- name: virtual_source_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_4
  states: {}
- name: virtual_source_1_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: RXCali_4
  states: {}

connections:
- [HIER_complex2float_0, '0', qtgui_time_sink_x_0, '0']
- [HIER_complex2float_1, '0', qtgui_time_sink_x_0, '1']
- [HIER_complex2float_2, '0', qtgui_time_sink_x_0, '2']
- [HIER_complex2float_3, '0', qtgui_time_sink_x_0, '3']
- [aoa_calc_phase_diff_1, '0', qtgui_number_sink_0, '0']
- [aoa_calc_phase_diff_1_0, '0', qtgui_number_sink_0, '1']
- [aoa_calc_phase_diff_1_1, '0', qtgui_number_sink_0, '2']
- [blocks_complex_to_magphase_0, '0', qtgui_number_sink_1, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_magphase_1, '0', qtgui_number_sink_1, '1']
- [blocks_complex_to_magphase_1, '1', qtgui_time_sink_x_0_1, '1']
- [blocks_complex_to_magphase_2, '0', qtgui_number_sink_1, '2']
- [blocks_complex_to_magphase_2, '1', qtgui_time_sink_x_0_1, '2']
- [blocks_complex_to_magphase_3, '0', qtgui_number_sink_1, '3']
- [blocks_complex_to_magphase_3, '1', qtgui_time_sink_x_0_1, '3']
- [blocks_delay_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_xx_2, '0']
- [blocks_delay_1, '0', blocks_multiply_const_xx_1, '0']
- [blocks_delay_1_0, '0', blocks_multiply_const_xx_3, '0']
- [blocks_multiply_const_xx_0, '0', HIER_complex2float_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_xx_1, '0', HIER_complex2float_1, '0']
- [blocks_multiply_const_xx_1, '0', virtual_sink_1_0, '0']
- [blocks_multiply_const_xx_2, '0', HIER_complex2float_2, '0']
- [blocks_multiply_const_xx_2, '0', virtual_sink_2_0, '0']
- [blocks_multiply_const_xx_3, '0', HIER_complex2float_3, '0']
- [blocks_multiply_const_xx_3, '0', virtual_sink_3_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '1', qtgui_sink_x_1, '0']
- [uhd_usrp_source_0, '1', virtual_sink_1, '0']
- [uhd_usrp_source_0, '2', qtgui_sink_x_3, '0']
- [uhd_usrp_source_0, '2', virtual_sink_2, '0']
- [uhd_usrp_source_0, '3', qtgui_sink_x_2, '0']
- [uhd_usrp_source_0, '3', virtual_sink_3, '0']
- [virtual_source_0_0_0_1, '0', blocks_delay_0, '0']
- [virtual_source_0_0_0_1_0, '0', blocks_complex_to_magphase_0, '0']
- [virtual_source_0_0_0_1_0_0, '0', aoa_calc_phase_diff_1, '0']
- [virtual_source_0_0_0_1_0_0, '0', aoa_calc_phase_diff_1_0, '0']
- [virtual_source_0_0_0_1_0_0, '0', aoa_calc_phase_diff_1_1, '0']
- [virtual_source_0_1_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0_1_0_0, '0', blocks_complex_to_magphase_2, '0']
- [virtual_source_0_1_0_0_0, '0', aoa_calc_phase_diff_1_0, '1']
- [virtual_source_1_0_0_0, '0', blocks_delay_1, '0']
- [virtual_source_1_0_0_0_0, '0', blocks_complex_to_magphase_1, '0']
- [virtual_source_1_0_0_0_0_0, '0', aoa_calc_phase_diff_1, '1']
- [virtual_source_1_1_0, '0', blocks_delay_1_0, '0']
- [virtual_source_1_1_0_0, '0', blocks_complex_to_magphase_3, '0']
- [virtual_source_1_1_0_0_0, '0', aoa_calc_phase_diff_1_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
