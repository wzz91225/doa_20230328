options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: TEST_X310_TWINRX_PhaseDiffernece
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: delay_1
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: delay_2
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '1166'
  states: {}
- name: gain_rx_A1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '93'
    value: '47'
  states: {}
- name: gain_rx_A2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '93'
    value: '48'
  states: {}
- name: gain_rx_B1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '93'
    value: '41'
  states: {}
- name: gain_rx_B2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '93'
    value: '43'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.2e6
  states: {}
- name: HIER_complex2float_0
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_0_0
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: aoa_calc_phase_diff_1
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_1
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: delay_2
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: pi
    min: '-pi'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0, 0
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    ant1: '"RX2"'
    ant2: '"RX1"'
    ant3: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    bw2: samp_rate
    bw3: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    gain0: gain_rx_A1
    gain1: gain_rx_A2
    gain2: gain_rx_B1
    gain3: gain_rx_B2
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RX_A1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RX_A2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RX_B1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: RX_B2
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: RX_A_DELAY
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: RX_B_DELAY
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX_A1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: RX_B1
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: RX_A2
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: RX_B2
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: RX_A_DELAY
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: RX_B_DELAY
  states: {}

connections:
- [HIER_complex2float_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [HIER_complex2float_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [aoa_calc_phase_diff_1, '0', qtgui_number_sink_0, '0']
- [blocks_add_xx_0, '0', blocks_delay_0, '0']
- [blocks_add_xx_1, '0', blocks_delay_1, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0_0, '0', blocks_null_sink_0, '1']
- [blocks_complex_to_magphase_0_0, '1', qtgui_time_sink_x_0_0, '1']
- [blocks_delay_0, '0', HIER_complex2float_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_delay_0, '0', virtual_sink_4, '0']
- [blocks_delay_1, '0', HIER_complex2float_0_0, '0']
- [blocks_delay_1, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_delay_1, '0', virtual_sink_5, '0']
- [uhd_usrp_source_0_1, '0', qtgui_sink_x_0_1, '0']
- [uhd_usrp_source_0_1, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0_1, '1', qtgui_sink_x_0_0_0, '0']
- [uhd_usrp_source_0_1, '1', virtual_sink_1, '0']
- [uhd_usrp_source_0_1, '2', qtgui_sink_x_0_1_0, '0']
- [uhd_usrp_source_0_1, '2', virtual_sink_2, '0']
- [uhd_usrp_source_0_1, '3', qtgui_sink_x_0_0_0_0, '0']
- [uhd_usrp_source_0_1, '3', virtual_sink_3, '0']
- [virtual_source_0_0_0, '0', blocks_add_xx_1, '0']
- [virtual_source_0_1, '0', blocks_add_xx_0, '0']
- [virtual_source_1_0_0, '0', blocks_add_xx_1, '1']
- [virtual_source_1_1, '0', blocks_add_xx_0, '1']
- [virtual_source_2_0, '0', aoa_calc_phase_diff_1, '0']
- [virtual_source_3_0, '0', aoa_calc_phase_diff_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
