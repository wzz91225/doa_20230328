options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: X310_SingleTX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 315.e6
  states: {}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    bw0: samp_rate
    center_freq0: center_freq
    gain0: gain_tx
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
