options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: EXP_ChsCalibration_4ch_X310TWINRX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: gain_rx1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    start: '0'
    step: '1'
    stop: '93'
    value: '40'
    widget: counter
  states: {}
- name: gain_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    start: '0'
    step: '1'
    stop: '93'
    value: '41'
    widget: counter
  states: {}
- name: gain_rx3
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2
    start: '0'
    step: '1'
    stop: '93'
    value: '39'
    widget: counter
  states: {}
- name: gain_rx4
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3
    start: '0'
    step: '1'
    stop: '93'
    value: '41'
    widget: counter
  states: {}
- name: multiply_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    start: '0.5'
    step: '1e-2'
    stop: '1.5'
    value: '1'
    widget: counter
  states: {}
- name: multiply_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    start: '0.5'
    step: '1e-2'
    stop: '1.5'
    value: '1.00'
    widget: counter
  states: {}
- name: multiply_3
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2
    start: '0.5'
    step: '1e-2'
    stop: '1.5'
    value: '1.05'
    widget: counter
  states: {}
- name: multiply_4
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3
    start: '0.5'
    step: '1e-2'
    stop: '1.5'
    value: '0.97'
    widget: counter
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e5
  states: {}
- name: HIER_complex2float_0
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_1
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_2
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_3
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: aoa_calc_phase_diff_1
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: aoa_calc_phase_diff_1_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: aoa_calc_phase_diff_1_1
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_1
    type: complex
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_2
    type: complex
  states: {}
- name: blocks_multiply_const_xx_2
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_3
    type: complex
  states: {}
- name: blocks_multiply_const_xx_3
  id: blocks_multiply_const_xx
  parameters:
    const: multiply_4
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: pi
    min: '-pi'
    nconnections: '3'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    ant1: '"RX2"'
    ant2: '"RX1"'
    ant3: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    bw2: samp_rate
    bw3: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    gain0: gain_rx1
    gain1: gain_rx2
    gain2: gain_rx3
    gain3: gain_rx4
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RX_A1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RX_A2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RX_B1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: RX_B2
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX_A1
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX_A1
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX_A1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: RX_B1
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: RX_A2
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: RX_B2
  states: {}

connections:
- [HIER_complex2float_0, '0', qtgui_time_sink_x_0, '0']
- [HIER_complex2float_1, '0', qtgui_time_sink_x_0, '1']
- [HIER_complex2float_2, '0', qtgui_time_sink_x_0, '2']
- [HIER_complex2float_3, '0', qtgui_time_sink_x_0, '3']
- [aoa_calc_phase_diff_1, '0', qtgui_number_sink_0, '0']
- [aoa_calc_phase_diff_1_0, '0', qtgui_number_sink_0, '1']
- [aoa_calc_phase_diff_1_1, '0', qtgui_number_sink_0, '2']
- [blocks_multiply_const_xx_0, '0', HIER_complex2float_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_xx_1, '0', HIER_complex2float_1, '0']
- [blocks_multiply_const_xx_1, '0', virtual_sink_1, '0']
- [blocks_multiply_const_xx_2, '0', HIER_complex2float_2, '0']
- [blocks_multiply_const_xx_2, '0', virtual_sink_2, '0']
- [blocks_multiply_const_xx_3, '0', HIER_complex2float_3, '0']
- [blocks_multiply_const_xx_3, '0', virtual_sink_3, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_xx_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_const_xx_1, '0']
- [uhd_usrp_source_0, '2', blocks_multiply_const_xx_2, '0']
- [uhd_usrp_source_0, '3', blocks_multiply_const_xx_3, '0']
- [virtual_source_0_0_0, '0', aoa_calc_phase_diff_1, '0']
- [virtual_source_0_0_0_0, '0', aoa_calc_phase_diff_1_0, '0']
- [virtual_source_0_0_0_0_0, '0', aoa_calc_phase_diff_1_1, '0']
- [virtual_source_0_1, '0', aoa_calc_phase_diff_1_0, '1']
- [virtual_source_1_0_0, '0', aoa_calc_phase_diff_1, '1']
- [virtual_source_1_1, '0', aoa_calc_phase_diff_1_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
