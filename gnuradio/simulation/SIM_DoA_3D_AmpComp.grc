options:
  parameters:
    author: zzaw
    description: under development
    generate_options: qt_gui
    id: SIM_DoA_3D_AmpComp
    output_language: python
    title: SIMULATION - DoA_3D_AmpComp
  states: {}

blocks:
- name: amp_noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '0.1'
  states: {}
- name: amp_signal
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
  states: {}
- name: freq_signal
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: samp_rate - 1
    value: 1e3
  states: {}
- name: real_azimuth_angle
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: real_pitch_angle
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: HIER_AddGaussianNoise_0
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amp_noise
    random_seed: '1'
  states: {}
- name: HIER_AddGaussianNoise_1
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amp_noise
    random_seed: '2'
  states: {}
- name: HIER_AddGaussianNoise_2
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amp_noise
    random_seed: '2'
  states: {}
- name: HIER_DoA_2D_AmpComp_PowerSpectrum_0
  id: HIER_DoA_2D_AmpComp_PowerSpectrum
  parameters:
    TH_Factor_Fall: '10'
    TH_Factor_Rise: '10'
    period_peak_detector: '0'
    samp_rate: samp_rate
  states: {state: disabled}
- name: HIER_DoA_3D_AmpComp_RMS_0
  id: HIER_DoA_3D_AmpComp_RMS
  parameters: {}
  states: {}
- name: HIER_RxSim_OrthogonalTripleChannel_0
  id: HIER_RxSim_OrthogonalTripleChannel
  parameters:
    azimuth_angle: real_azimuth_angle
    pitch_angle: real_pitch_angle
  states: {}
- name: HIER_complex2float_0
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_1
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_2
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_3
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_signal
    freq: freq_signal
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate * 1e6
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: under development
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: doa_rms_azimuth
    max: '90'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: doa_rms_pitch
    max: '90'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: CH1 SNR(dB)
    label2: CH2 SNR(dB)
    label3: CH3 SNR(dB)
    max: '50'
    min: '-50'
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: detected
    min: '0'
    type: byte
  states: {state: disabled}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: freq1
    label2: freq2
    max: samp_rate - 1
    min: '0'
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: signal
    label2: channel1
    label3: channel2
    label4: channel3
    nconnections: '4'
    size: int(freq_signal)
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: vsink_doa_rms_azimuth
  id: virtual_sink
  parameters:
    stream_id: '403'
  states: {}
- name: vsink_doa_rms_pitch
  id: virtual_sink
  parameters:
    stream_id: '404'
  states: {}
- name: vsink_rx_ch1
  id: virtual_sink
  parameters:
    stream_id: '4'
  states: {}
- name: vsink_rx_ch2
  id: virtual_sink
  parameters:
    stream_id: '5'
  states: {}
- name: vsink_rx_ch3
  id: virtual_sink
  parameters:
    stream_id: '6'
  states: {}
- name: vsink_signal
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: vsink_tx_ch1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: vsink_tx_ch2
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: vsink_tx_ch3
  id: virtual_sink
  parameters:
    stream_id: '3'
  states: {}
- name: vsrc_rx_ch1
  id: virtual_source
  parameters:
    stream_id: '4'
  states: {}
- name: vsrc_rx_ch1_0
  id: virtual_source
  parameters:
    stream_id: '4'
  states: {}
- name: vsrc_rx_ch2
  id: virtual_source
  parameters:
    stream_id: '5'
  states: {}
- name: vsrc_rx_ch2_0
  id: virtual_source
  parameters:
    stream_id: '5'
  states: {}
- name: vsrc_rx_ch2_0_0
  id: virtual_source
  parameters:
    stream_id: '6'
  states: {}
- name: vsrc_rx_ch3
  id: virtual_source
  parameters:
    stream_id: '6'
  states: {}
- name: vsrc_signal
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: vsrc_tx_ch1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: vsrc_tx_ch2
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}
- name: vsrc_tx_ch3
  id: virtual_source
  parameters:
    stream_id: '3'
  states: {}

connections:
- [HIER_AddGaussianNoise_0, '0', vsink_rx_ch1, '0']
- [HIER_AddGaussianNoise_0, '1', qtgui_number_sink_2, '0']
- [HIER_AddGaussianNoise_1, '0', vsink_rx_ch2, '0']
- [HIER_AddGaussianNoise_1, '1', qtgui_number_sink_2, '1']
- [HIER_AddGaussianNoise_2, '0', vsink_rx_ch3, '0']
- [HIER_AddGaussianNoise_2, '1', qtgui_number_sink_2, '2']
- [HIER_DoA_2D_AmpComp_PowerSpectrum_0, '0', qtgui_number_sink_3, '0']
- [HIER_DoA_2D_AmpComp_PowerSpectrum_0, '1', qtgui_number_sink_4, '0']
- [HIER_DoA_2D_AmpComp_PowerSpectrum_0, '2', qtgui_number_sink_4, '1']
- [HIER_DoA_3D_AmpComp_RMS_0, '0', qtgui_number_sink_0, '0']
- [HIER_DoA_3D_AmpComp_RMS_0, '0', vsink_doa_rms_azimuth, '0']
- [HIER_DoA_3D_AmpComp_RMS_0, '1', qtgui_number_sink_1, '0']
- [HIER_DoA_3D_AmpComp_RMS_0, '1', vsink_doa_rms_pitch, '0']
- [HIER_RxSim_OrthogonalTripleChannel_0, '0', vsink_tx_ch1, '0']
- [HIER_RxSim_OrthogonalTripleChannel_0, '1', vsink_tx_ch2, '0']
- [HIER_RxSim_OrthogonalTripleChannel_0, '2', vsink_tx_ch3, '0']
- [HIER_complex2float_0, '0', qtgui_time_sink_x_0, '0']
- [HIER_complex2float_1, '0', qtgui_time_sink_x_0, '1']
- [HIER_complex2float_2, '0', qtgui_time_sink_x_0, '2']
- [HIER_complex2float_3, '0', qtgui_time_sink_x_0, '3']
- [analog_sig_source_x_0, '0', HIER_RxSim_OrthogonalTripleChannel_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', vsink_signal, '0']
- [vsrc_rx_ch1, '0', HIER_DoA_3D_AmpComp_RMS_0, '0']
- [vsrc_rx_ch1_0, '0', HIER_complex2float_1, '0']
- [vsrc_rx_ch2, '0', HIER_DoA_3D_AmpComp_RMS_0, '1']
- [vsrc_rx_ch2_0, '0', HIER_complex2float_2, '0']
- [vsrc_rx_ch2_0_0, '0', HIER_complex2float_3, '0']
- [vsrc_rx_ch3, '0', HIER_DoA_3D_AmpComp_RMS_0, '2']
- [vsrc_signal, '0', HIER_complex2float_0, '0']
- [vsrc_tx_ch1, '0', HIER_AddGaussianNoise_0, '0']
- [vsrc_tx_ch2, '0', HIER_AddGaussianNoise_1, '0']
- [vsrc_tx_ch3, '0', HIER_AddGaussianNoise_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
