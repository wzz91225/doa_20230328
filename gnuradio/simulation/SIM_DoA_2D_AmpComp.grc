options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: SIM_DoA_2D_AmpComp
    output_language: python
    title: SIMULATION - DoA_2D_AmpComp
  states: {}

blocks:
- name: amp_noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '0.1'
  states: {}
- name: amp_signal
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
  states: {}
- name: real_angle
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: HIER_AddGaussianNoise_0
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amp_noise
    random_seed: '1'
  states: {}
- name: HIER_AddGaussianNoise_1
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amp_noise
    random_seed: '2'
  states: {}
- name: HIER_DoA_2D_AmpComp_PowerSpectrum_0
  id: HIER_DoA_2D_AmpComp_PowerSpectrum
  parameters:
    TH_Factor_Fall: '10'
    TH_Factor_Rise: '10'
    period_peak_detector: '1'
    samp_rate: samp_rate
  states: {}
- name: HIER_DoA_2D_AmpComp_RMS_0
  id: HIER_DoA_2D_AmpComp_RMS
  parameters:
    samp_rate: samp_rate
  states: {}
- name: HIER_SignalGenerator_AmpComp_2D_0
  id: HIER_SignalGenerator_AmpComp_2D
  parameters:
    parameter_0: real_angle
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_signal
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: DoA - pow
    max: '90'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: DoA - rms
    max: '90'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: CH1 SNR(dB)
    label2: CH2 SNR(dB)
    max: '50'
    min: '-50'
    nconnections: '2'
    type: float
  states: {}

connections:
- [HIER_AddGaussianNoise_0, '0', HIER_DoA_2D_AmpComp_PowerSpectrum_0, '0']
- [HIER_AddGaussianNoise_0, '0', HIER_DoA_2D_AmpComp_RMS_0, '0']
- [HIER_AddGaussianNoise_0, '1', qtgui_number_sink_2, '0']
- [HIER_AddGaussianNoise_1, '0', HIER_DoA_2D_AmpComp_PowerSpectrum_0, '1']
- [HIER_AddGaussianNoise_1, '0', HIER_DoA_2D_AmpComp_RMS_0, '1']
- [HIER_AddGaussianNoise_1, '1', qtgui_number_sink_2, '1']
- [HIER_DoA_2D_AmpComp_PowerSpectrum_0, '3', qtgui_number_sink_0, '0']
- [HIER_DoA_2D_AmpComp_RMS_0, '0', qtgui_number_sink_1, '0']
- [HIER_SignalGenerator_AmpComp_2D_0, '0', HIER_AddGaussianNoise_0, '0']
- [HIER_SignalGenerator_AmpComp_2D_0, '1', HIER_AddGaussianNoise_1, '0']
- [analog_sig_source_x_0, '0', HIER_SignalGenerator_AmpComp_2D_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
