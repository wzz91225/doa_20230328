options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: SIM_DoA_2D_AmpComp
    output_language: python
    title: SIMULATION - DoA_2D_AmpComp
  states: {}

blocks:
- name: amp_noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '0.1'
  states: {}
- name: amp_signal
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
  states: {}
- name: freq_signal
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: samp_rate - 1
    value: 1e3
  states: {}
- name: real_angle
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: HIER_AddGaussianNoise_0
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amp_noise
    random_seed: '1'
  states: {}
- name: HIER_AddGaussianNoise_1
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amp_noise
    random_seed: '2'
  states: {}
- name: HIER_DataError_0
  id: HIER_DataError
  parameters: {}
  states: {state: disabled}
- name: HIER_DataError_1
  id: HIER_DataError
  parameters: {}
  states: {state: disabled}
- name: HIER_DoA_2D_AmpComp_PowerSpectrum_0
  id: HIER_DoA_2D_AmpComp_PowerSpectrum
  parameters:
    TH_Factor_Fall: '10'
    TH_Factor_Rise: '10'
    period_peak_detector: '0'
    samp_rate: samp_rate
  states: {}
- name: HIER_DoA_2D_AmpComp_RMS_0
  id: HIER_DoA_2D_AmpComp_RMS
  parameters:
    samp_rate: samp_rate
  states: {}
- name: HIER_SignalGenerator_AmpComp_2D_0
  id: HIER_SignalGenerator_AmpComp_2D
  parameters:
    parameter_0: real_angle
  states: {}
- name: HIER_complex2float_0
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_1
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: HIER_complex2float_2
  id: HIER_complex2float
  parameters: {}
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: real_angle
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_signal
    freq: freq_signal
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate * 1e6
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: DoA - pow
    max: '90'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: DoA - rms
    max: '90'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: CH1 SNR(dB)
    label2: CH2 SNR(dB)
    max: '50'
    min: '-50'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: detected
    min: '0'
    type: byte
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: freq1
    label2: freq2
    max: samp_rate - 1
    min: '0'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_5
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: err - pow
    max: '100'
    min: '0'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_6
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: err - rms
    max: '100'
    min: '0'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: signal
    label2: channel1
    label3: channel2
    nconnections: '3'
    size: int(freq_signal)
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: vsink_doa_pow
  id: virtual_sink
  parameters:
    stream_id: '301'
  states: {}
- name: vsink_doa_rms
  id: virtual_sink
  parameters:
    stream_id: '302'
  states: {}
- name: vsink_rx_ch1
  id: virtual_sink
  parameters:
    stream_id: '3'
  states: {}
- name: vsink_rx_ch2
  id: virtual_sink
  parameters:
    stream_id: '4'
  states: {}
- name: vsink_signal
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: vsink_tx_ch1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: vsink_tx_ch2
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: vsrc_doa_pow
  id: virtual_source
  parameters:
    stream_id: '301'
  states: {}
- name: vsrc_doa_rms
  id: virtual_source
  parameters:
    stream_id: '302'
  states: {}
- name: vsrc_rx_ch1
  id: virtual_source
  parameters:
    stream_id: '3'
  states: {}
- name: vsrc_rx_ch1_0
  id: virtual_source
  parameters:
    stream_id: '3'
  states: {}
- name: vsrc_rx_ch2
  id: virtual_source
  parameters:
    stream_id: '4'
  states: {}
- name: vsrc_rx_ch2_0
  id: virtual_source
  parameters:
    stream_id: '4'
  states: {}
- name: vsrc_signal
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: vsrc_tx_ch1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: vsrc_tx_ch2
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}

connections:
- [HIER_AddGaussianNoise_0, '0', vsink_rx_ch1, '0']
- [HIER_AddGaussianNoise_0, '1', qtgui_number_sink_2, '0']
- [HIER_AddGaussianNoise_1, '0', vsink_rx_ch2, '0']
- [HIER_AddGaussianNoise_1, '1', qtgui_number_sink_2, '1']
- [HIER_DataError_0, '0', qtgui_number_sink_5, '0']
- [HIER_DataError_1, '0', qtgui_number_sink_6, '0']
- [HIER_DoA_2D_AmpComp_PowerSpectrum_0, '0', qtgui_number_sink_3, '0']
- [HIER_DoA_2D_AmpComp_PowerSpectrum_0, '1', qtgui_number_sink_4, '0']
- [HIER_DoA_2D_AmpComp_PowerSpectrum_0, '2', qtgui_number_sink_4, '1']
- [HIER_DoA_2D_AmpComp_PowerSpectrum_0, '3', vsink_doa_pow, '0']
- [HIER_DoA_2D_AmpComp_RMS_0, '0', vsink_doa_rms, '0']
- [HIER_SignalGenerator_AmpComp_2D_0, '0', vsink_tx_ch1, '0']
- [HIER_SignalGenerator_AmpComp_2D_0, '1', vsink_tx_ch2, '0']
- [HIER_complex2float_0, '0', qtgui_time_sink_x_0, '0']
- [HIER_complex2float_1, '0', qtgui_time_sink_x_0, '1']
- [HIER_complex2float_2, '0', qtgui_time_sink_x_0, '2']
- [analog_const_source_x_0, '0', HIER_DataError_0, '1']
- [analog_const_source_x_0, '0', HIER_DataError_1, '1']
- [analog_sig_source_x_0, '0', HIER_SignalGenerator_AmpComp_2D_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', vsink_signal, '0']
- [vsrc_doa_pow, '0', HIER_DataError_0, '0']
- [vsrc_doa_pow, '0', qtgui_number_sink_0, '0']
- [vsrc_doa_rms, '0', HIER_DataError_1, '0']
- [vsrc_doa_rms, '0', qtgui_number_sink_1, '0']
- [vsrc_rx_ch1, '0', HIER_DoA_2D_AmpComp_PowerSpectrum_0, '0']
- [vsrc_rx_ch1, '0', HIER_DoA_2D_AmpComp_RMS_0, '0']
- [vsrc_rx_ch1_0, '0', HIER_complex2float_1, '0']
- [vsrc_rx_ch2, '0', HIER_DoA_2D_AmpComp_PowerSpectrum_0, '1']
- [vsrc_rx_ch2, '0', HIER_DoA_2D_AmpComp_RMS_0, '1']
- [vsrc_rx_ch2_0, '0', HIER_complex2float_2, '0']
- [vsrc_signal, '0', HIER_complex2float_0, '0']
- [vsrc_tx_ch1, '0', HIER_AddGaussianNoise_0, '0']
- [vsrc_tx_ch2, '0', HIER_AddGaussianNoise_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
