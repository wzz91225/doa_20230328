options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: SIM_DoA_2D_AmpComp
    output_language: python
    title: SIMULATION - DoA_2D_AmpComp
  states: {}

blocks:
- name: amp_noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '0.1'
  states: {}
- name: amp_signal
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
  states: {}
- name: real_angle
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '90'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: real_angle
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: amp_noise
    noise_type: analog.GR_GAUSSIAN
    seed: '1'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: amp_noise
    noise_type: analog.GR_GAUSSIAN
    seed: '2'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_signal
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: d20230403_hier_cos_angle_epb_0
  id: d20230403_hier_cos_angle_epb
  parameters: {}
  states: {}
- name: d20230403_hier_sin_angle_epb_0
  id: d20230403_hier_sin_angle_epb
  parameters: {}
  states: {}
- name: d20230406_hier_DoA_2D_AmpComp_PowerSpectrum_0
  id: d20230406_hier_DoA_2D_AmpComp_PowerSpectrum
  parameters:
    TH_Factor_Fall: '10'
    TH_Factor_Rise: '10'
    period_peak_detector: '1'
    samp_rate: 32e3
  states: {}
- name: d20230406_hier_DoA_2D_AmpComp_RMS_0
  id: d20230406_hier_DoA_2D_AmpComp_RMS
  parameters:
    TH_Factor_Fall: '10'
    TH_Factor_Rise: '10'
    period_peak_detector: '1'
    samp_rate: 32e3
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: power
    max: '90'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: rms^1
    max: '90'
    min: '0'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_1, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_2, '0', d20230403_hier_cos_angle_epb_0, '0']
- [analog_const_source_x_2, '0', d20230403_hier_sin_angle_epb_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_1, '0', blocks_add_xx_1, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', d20230406_hier_DoA_2D_AmpComp_PowerSpectrum_0, '0']
- [blocks_add_xx_0, '0', d20230406_hier_DoA_2D_AmpComp_RMS_0, '0']
- [blocks_add_xx_1, '0', d20230406_hier_DoA_2D_AmpComp_PowerSpectrum_0, '1']
- [blocks_add_xx_1, '0', d20230406_hier_DoA_2D_AmpComp_RMS_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_1, '0']
- [d20230403_hier_cos_angle_epb_0, '0', blocks_float_to_complex_0_0, '0']
- [d20230403_hier_sin_angle_epb_0, '0', blocks_float_to_complex_0, '0']
- [d20230406_hier_DoA_2D_AmpComp_PowerSpectrum_0, '3', qtgui_number_sink_0, '0']
- [d20230406_hier_DoA_2D_AmpComp_RMS_0, '0', qtgui_number_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
