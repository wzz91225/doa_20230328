options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: SIM_DoA_PhaseComp
    output_language: python
    title: Simulation_DoA_PhaseComp
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
  states: {}
- name: amplitude_noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '0'
  states: {}
- name: c
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: distance_antenna
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: c/frequency
    value: c/frequency/2
  states: {}
- name: distance_relative
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: c/frequency
    stop: 100*c/frequency
    value: 1e1*c/frequency
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: int(samp_rate / 2)
    value: 32e3
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: relative_DoA
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '180'
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e6
  states: {}
- name: signal_multiplying
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
  states: {}
- name: HIER_AddGaussianNoise_0
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amplitude_noise
    random_seed: '10492'
  states: {}
- name: HIER_DataError_0
  id: HIER_DataError
  parameters: {}
  states: {}
- name: HIER_DataError_0_0
  id: HIER_DataError
  parameters: {}
  states: {}
- name: HIER_DoA_PhaseComp_0
  id: HIER_DoA_PhaseComp
  parameters:
    c: c
    delta_d: distance_antenna
    frequency: frequency
    pi: pi
  states: {}
- name: HIER_DoA_PhaseComp_0_0
  id: HIER_DoA_PhaseComp
  parameters:
    c: c
    delta_d: distance_antenna
    frequency: frequency
    pi: pi
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: relative_DoA
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: relative_DoA
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_calc_phase_diff_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: frequency * 1.1
    low_cutoff_freq: frequency * 0.9
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: frequency * 0.2
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: frequency * 1.1
    low_cutoff_freq: frequency * 0.9
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: frequency * 0.2
    win: window.WIN_HAMMING
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    showports: 'True'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    showports: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: signal_multiplying
    type: complex
  states: {}
- name: blocks_var_to_msg_1_0
  id: blocks_var_to_msg
  parameters:
    msgname: frequency
    target: frequency
  states: {}
- name: blocks_var_to_msg_1_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: dis_r
    target: distance_relative
  states: {}
- name: blocks_var_to_msg_1_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: DoA
    target: relative_DoA
  states: {}
- name: blocks_var_to_msg_1_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: dis_at
    target: distance_antenna
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    DoA: relative_DoA
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=32e3, pi=3.14159, c=299.792e6, frequency=0, dis_r=0, DoA=0, dis_at=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='distance_calc(epb)',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.samp_rate = samp_rate
              self.pi = pi
              self.c = c

              self.frequency = frequency
              self.dis_r = dis_r
              self.DoA = DoA
              self.dis_at = dis_at

              # 注册消息端口
              self.message_port_register_in(pmt.intern("update_params"))
              self.set_msg_handler(pmt.intern("update_params"), self.handle_msg)

              self.message_port_register_out(pmt.intern('delay_B'))
              self.message_port_register_out(pmt.intern('delay_A'))


              # # calc
              # alpha_sin = np.sin(self.DoA * self.pi / 180)
              # alpha_cos = np.cos(self.DoA * self.pi / 180)
              # distance_A = np.sqrt((self.dis_r * alpha_cos - self.dis_at/2)**2 + (self.dis_r * alpha_sin)**2)
              # distance_B = np.sqrt((self.dis_r * alpha_cos + self.dis_at/2)**2 + (self.dis_r * alpha_sin)**2)
              # delay_A = int(distance_A / self.c * self.samp_rate)
              # delay_B = int(distance_B / self.c * self.samp_rate)

              # self.message_port_pub(pmt.intern("delay_A"), pmt.from_long(delay_A))
              # self.message_port_pub(pmt.intern("delay_B"), pmt.from_long(delay_B))
              # print(distance_A, distance_A)
              # print(delay_A, delay_B)
          


          def handle_msg(self, msg):
              # 解析消息并更新参数
              if pmt.is_pair(msg):
                  key = pmt.to_python(pmt.car(msg))
                  value = pmt.to_python(pmt.cdr(msg))
                  print(key, value)

                  if key == "frequency":
                      self.frequency = value
                  elif key == "dis_r":
                      self.dis_r = value
                  elif key == "DoA":
                      self.DoA = value
                  elif key == "dis_at":
                      self.dis_at = value

                  # calc
                  alpha_sin = np.sin(self.DoA * self.pi / 180)
                  alpha_cos = np.cos(self.DoA * self.pi / 180)
                  distance_A = np.sqrt((self.dis_r * alpha_cos - self.dis_at/2)**2 + (self.dis_r * alpha_sin)**2)
                  distance_B = np.sqrt((self.dis_r * alpha_cos + self.dis_at/2)**2 + (self.dis_r * alpha_sin)**2)
                  delay_A = int(distance_A / self.c * self.samp_rate)
                  delay_B = int(distance_B / self.c * self.samp_rate)

                  self.message_port_pub(pmt.intern("delay_A"), pmt.from_long(delay_A))
                  self.message_port_pub(pmt.intern("delay_B"), pmt.from_long(delay_B))
                  print(distance_A, distance_B)
                  print(delay_A, delay_B)


          # def work(self, input_items, output_items):
          #     """"""
          #     return len(output_items[0])
    c: c
    dis_at: distance_antenna
    dis_r: distance_relative
    frequency: frequency
    pi: pi
    samp_rate: samp_rate
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    nconnections: '3'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: err
    label2: '%'
    max: '100'
    min: '0'
    nconnections: '2'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: err
    label2: '%'
    max: '100'
    min: '0'
    nconnections: '2'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"SNR"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.010'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.010'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [HIER_AddGaussianNoise_0, '0', blocks_delay_0, '0']
- [HIER_AddGaussianNoise_0, '0', blocks_delay_0_0, '0']
- [HIER_AddGaussianNoise_0, '1', qtgui_number_sink_2, '0']
- [HIER_DataError_0, '0', qtgui_number_sink_1, '0']
- [HIER_DataError_0, '1', qtgui_number_sink_1, '1']
- [HIER_DataError_0_0, '0', qtgui_number_sink_1_0, '0']
- [HIER_DataError_0_0, '1', qtgui_number_sink_1_0, '1']
- [HIER_DoA_PhaseComp_0, '1', HIER_DataError_0, '0']
- [HIER_DoA_PhaseComp_0, '1', qtgui_number_sink_0, '0']
- [HIER_DoA_PhaseComp_0_0, '0', qtgui_number_sink_0_1, '1']
- [HIER_DoA_PhaseComp_0_0, '1', HIER_DataError_0_0, '0']
- [HIER_DoA_PhaseComp_0_0, '1', qtgui_number_sink_0_0, '0']
- [HIER_DoA_PhaseComp_0_0, '1', qtgui_number_sink_0_1, '2']
- [analog_const_source_x_0, '0', HIER_DataError_0, '1']
- [analog_const_source_x_0_0, '0', HIER_DataError_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_const_xx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [aoa_calc_phase_diff_0, '0', qtgui_number_sink_0_1, '0']
- [band_pass_filter_0, '0', HIER_DoA_PhaseComp_0_0, '0']
- [band_pass_filter_0, '0', aoa_calc_phase_diff_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0_0, '1']
- [band_pass_filter_0_0, '0', HIER_DoA_PhaseComp_0_0, '1']
- [band_pass_filter_0_0, '0', aoa_calc_phase_diff_0, '1']
- [band_pass_filter_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_delay_0, '0', HIER_DoA_PhaseComp_0, '0']
- [blocks_delay_0, '0', band_pass_filter_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', HIER_DoA_PhaseComp_0, '1']
- [blocks_delay_0_0, '0', band_pass_filter_0_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_multiply_const_xx_0, '0', HIER_AddGaussianNoise_0, '0']
- [blocks_var_to_msg_1_0, msgout, epy_block_0, update_params]
- [blocks_var_to_msg_1_0_0, msgout, epy_block_0, update_params]
- [blocks_var_to_msg_1_0_0_0, msgout, epy_block_0, update_params]
- [blocks_var_to_msg_1_0_0_0_0, msgout, epy_block_0, update_params]
- [epy_block_0, delay_A, blocks_delay_0, dly]
- [epy_block_0, delay_B, blocks_delay_0_0, dly]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
