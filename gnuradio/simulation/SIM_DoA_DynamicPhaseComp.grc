options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: SIM_DoA_DelayPhaseComp
    output_language: python
    title: Simulation_DoA_DelayPhaseComp
  states: {}

blocks:
- name: actual_azimuth
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '180'
    value: '90'
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
    widget: counter
  states: {}
- name: amplitude_noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '0'
  states: {}
- name: average_time
  id: variable
  parameters:
    value: '8'
  states: {}
- name: c
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: delta_t
  id: variable_qtgui_range
  parameters:
    start: '1e-6'
    step: '1e-6'
    stop: c/frequency/velocity
    value: c/frequency/2/velocity
    widget: counter
  states: {}
- name: distance_relative
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: c/frequency
    stop: 1e5*c/frequency
    value: 10*c/frequency
    widget: counter
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: int(samp_rate / 2)
    value: 32e3
    widget: counter
  states: {}
- name: frequency_shift
  id: variable_qtgui_range
  parameters:
    start: '-1e2'
    step: '1e-2'
    stop: +1e2
    value: '0'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: frequency*100
  states: {}
- name: signal_multiplying
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
    widget: counter
  states: {}
- name: velocity
  id: variable_qtgui_range
  parameters:
    start: 1e3
    step: '1'
    stop: 1000e3
    value: 1000e3
    widget: counter
  states: {}
- name: HIER_AddGaussianNoise_0
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amplitude_noise
    random_seed: '10492'
  states: {}
- name: HIER_DataError_0_0
  id: HIER_DataError
  parameters: {}
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: actual_azimuth
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aoa_calc_phase_diff_0
  id: aoa_calc_phase_diff
  parameters:
    node_idx: '2'
    norm_spacing: '0.5'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: frequency * 1.1
    low_cutoff_freq: frequency * 0.9
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: frequency * 0.2
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: frequency * 1.1
    low_cutoff_freq: frequency * 0.9
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: frequency * 0.2
    win: window.WIN_HAMMING
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    showports: 'True'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    showports: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: signal_multiplying
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_var_to_msg_1_0
  id: blocks_var_to_msg
  parameters:
    msgname: frequency
    target: frequency
  states: {}
- name: blocks_var_to_msg_1_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: dis_r
    target: distance_relative
  states: {}
- name: blocks_var_to_msg_1_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: actual_azimuth
    target: actual_azimuth
  states: {}
- name: blocks_var_to_msg_1_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: v
    target: velocity
  states: {}
- name: blocks_var_to_msg_1_0_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: delta_t
    target: delta_t
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=32e3, pi=3.14159, c=299.792e6, frequency=0, dis_r=0, azimuth=0, v=0, delta_t=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='delay_calc(epb)',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.samp_rate = samp_rate
              self.pi = pi
              self.c = c

              self.frequency = frequency
              self.dis_r = dis_r
              self.azimuth = azimuth
              self.v = v
              self.delta_t = delta_t

              # 注册消息端口
              self.message_port_register_in(pmt.intern("update_params"))
              self.set_msg_handler(pmt.intern("update_params"), self.handle_msg)

              self.message_port_register_out(pmt.intern('delay_2'))
              self.message_port_register_out(pmt.intern('delay_1'))
          

          def handle_msg(self, msg):
              # 解析消息并更新参数
              if pmt.is_pair(msg):
                  key = pmt.to_python(pmt.car(msg))
                  value = pmt.to_python(pmt.cdr(msg))
                  print(key, value)

                  if key == "frequency":
                      self.frequency = value
                  elif key == "dis_r":
                      self.dis_r = value
                  elif key == "azimuth":
                      self.azimuth = value
                  elif key == "v":
                      self.v = value
                  elif key == "delta_t":
                      self.delta_t = value

                  # compute
                  alpha_sin = np.sin(self.azimuth * self.pi / 180)
                  alpha_cos = np.cos(self.azimuth * self.pi / 180)
                  dis_s = self.v * self.delta_t
                  distance_1 = np.sqrt((self.dis_r * alpha_cos + dis_s)**2 + (self.dis_r * alpha_sin)**2)
                  distance_2 = self.dis_r
                  delay_1 = int((distance_1 / self.c) * self.samp_rate)
                  delay_2 = int((distance_2 / self.c + self.delta_t) * self.samp_rate)

                  self.message_port_pub(pmt.intern("delay_1"), pmt.from_long(delay_1))
                  self.message_port_pub(pmt.intern("delay_2"), pmt.from_long(delay_2))
                  print(distance_1, distance_2)
                  print(delay_1, delay_2)


          # def work(self, input_items, output_items):
          #     """"""
          #     return len(output_items[0])
    azimuth: actual_azimuth
    c: c
    delta_t: delta_t
    dis_r: distance_relative
    frequency: frequency
    pi: pi
    samp_rate: samp_rate
    v: velocity
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block - Dynamic Phase Comparison"""

          def __init__(self, pi=3.141592653589793, c=299792458, frequency=0, v_t=0, delta_t=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Dynamic Phase Comparison (EPB)',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.pi = pi
              self.c = c
              self.frequency = frequency
              self.v_t = v_t
              self.delta_t = delta_t

          def work(self, input_items, output_items):
              """Dynamic Phase Comparison"""
              actual_delta_phi = - input_items[0] + 2 * self.pi * self.frequency * self.delta_t
              actual_delta_phi = (actual_delta_phi + self.pi) % (2 * self.pi) - self.pi
              alpha = np.arccos(actual_delta_phi * self.c / self.frequency / 2 / self.pi / self.v_t / self.delta_t)
              output_items[0][:] = alpha
              output_items[1][:] = np.rad2deg(alpha)
              # output_items[2][:] = actual_delta_phi
              return len(output_items[0])
    c: c
    delta_t: delta_t
    frequency: frequency+frequency_shift
    pi: pi
    v_t: velocity
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"SNR (Average)"'
    type: float
    update_time: average_time
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    name: '"DoA Result (Realtime)"'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    name: '"DoA Result (Average )"'
    type: float
    update_time: average_time
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: err
    label2: '%'
    max: '100'
    min: '0'
    name: '"Result Error (Average)"'
    nconnections: '2'
    type: float
    update_time: average_time
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.010'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: DF_Result
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Signal_1
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Signal_2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: DF_Result
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Signal_1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Signal_2
  states: {}

connections:
- [HIER_AddGaussianNoise_0, '0', blocks_delay_0, '0']
- [HIER_AddGaussianNoise_0, '0', blocks_delay_0_0, '0']
- [HIER_AddGaussianNoise_0, '1', qtgui_number_sink_0, '0']
- [HIER_DataError_0_0, '0', qtgui_number_sink_3, '0']
- [HIER_DataError_0_0, '1', qtgui_number_sink_3, '1']
- [analog_const_source_x_0_0, '0', HIER_DataError_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_const_xx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [aoa_calc_phase_diff_0, '0', epy_block_0_0, '0']
- [band_pass_filter_0, '0', aoa_calc_phase_diff_0, '0']
- [band_pass_filter_0_0, '0', aoa_calc_phase_diff_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0, '0', virtual_sink_1, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0, '0', virtual_sink_2, '0']
- [blocks_multiply_const_xx_0, '0', HIER_AddGaussianNoise_0, '0']
- [blocks_var_to_msg_1_0, msgout, epy_block_0, update_params]
- [blocks_var_to_msg_1_0_0, msgout, epy_block_0, update_params]
- [blocks_var_to_msg_1_0_0_0, msgout, epy_block_0, update_params]
- [blocks_var_to_msg_1_0_0_0_0, msgout, epy_block_0, update_params]
- [blocks_var_to_msg_1_0_0_0_0_0, msgout, epy_block_0, update_params]
- [epy_block_0, delay_1, blocks_delay_0, dly]
- [epy_block_0, delay_2, blocks_delay_0_0, dly]
- [epy_block_0_0, '0', blocks_null_sink_0, '0']
- [epy_block_0_0, '1', virtual_sink_0, '0']
- [virtual_source_0, '0', HIER_DataError_0_0, '0']
- [virtual_source_0, '0', qtgui_number_sink_1, '0']
- [virtual_source_0, '0', qtgui_number_sink_2, '0']
- [virtual_source_1, '0', band_pass_filter_0, '0']
- [virtual_source_2, '0', band_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
