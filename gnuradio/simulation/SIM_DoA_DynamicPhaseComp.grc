options:
  parameters:
    author: zzaw
    generate_options: qt_gui
    id: SIM_DoA_DynamicPhaseComp
    output_language: python
    title: Simulation_DoA_DynamicPhaseComp
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '1'
    widget: counter
  states: {}
- name: amplitude_noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '0'
  states: {}
- name: c
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: int(samp_rate / 2)
    value: 32e3
    widget: counter
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e6
  states: {}
- name: HIER_AddGaussianNoise_0
  id: HIER_AddGaussianNoise
  parameters:
    amplitude: amplitude_noise
    random_seed: '10492'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    showports: 'True'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block"""

          def __init__(self, samp_rate=32e3, pi=3.14159, c=299.792e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Delay_Calculating(epb)',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.samp_rate = samp_rate
              self.pi = pi
              self.c = c


              # 注册消息端口
              self.message_port_register_in(pmt.intern("update_params"))
              self.set_msg_handler(pmt.intern("update_params"), self.handle_msg)

              self.message_port_register_out(pmt.intern('delay_time'))



          def handle_msg(self, msg):
              # 解析消息并更新参数
              if pmt.is_pair(msg):
                  pass



          # def work(self, input_items, output_items):
          #     """example: multiply with constant"""
          #     output_items[0][:] = input_items[0] * self.example_param
          #     return len(output_items[0])
    c: '299792000.0'
    pi: '3.14159'
    samp_rate: '32000.0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: under development
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"SNR (Average)"'
    type: float
    update_time: '0.010'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.010'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [HIER_AddGaussianNoise_0, '0', blocks_delay_0, '0']
- [HIER_AddGaussianNoise_0, '0', qtgui_time_sink_x_0, '0']
- [HIER_AddGaussianNoise_0, '1', qtgui_number_sink_0, '0']
- [analog_sig_source_x_0, '0', HIER_AddGaussianNoise_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [epy_block_0, delay_time, blocks_delay_0, dly]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
